OnChipPowerDeliveryNetwork
*OnChipTopPlane
R1000000001_1000001001 1000000001 1000001001 2.500000e-02
L1000001001_1000002001 1000001001 1000002001 2.911707e-15
R1000002001_1000003001 1000002001 1000003001 2.500000e-02
L1000003001_1000004001 1000003001 1000004001 2.911707e-15
R1000000001_1001000001 1000000001 1001000001 2.500000e-02
L1001000001_1002000001 1001000001 1002000001 2.911707e-15
R1000002001_1001002001 1000002001 1001002001 2.500000e-02
L1001002001_1002002001 1001002001 1002002001 2.911707e-15
R1000004001_1001004001 1000004001 1001004001 2.500000e-02
L1001004001_1002004001 1001004001 1002004001 2.911707e-15
*OnChipBottomPlane
R1000000002_1000001002 1000000002 1000001002 2.500000e-02
L1000001002_1000002002 1000001002 1000002002 2.911707e-15
R1000002002_1000003002 1000002002 1000003002 2.500000e-02
L1000003002_1000004002 1000003002 1000004002 2.911707e-15
R1000000002_1001000002 1000000002 1001000002 2.500000e-02
L1001000002_1002000002 1001000002 1002000002 2.911707e-15
R1000002002_1001002002 1000002002 1001002002 2.500000e-02
L1001002002_1002002002 1001002002 1002002002 2.911707e-15
R1000004002_1001004002 1000004002 1001004002 2.500000e-02
L1001004002_1002004002 1001004002 1002004002 2.911707e-15
*PowerDeliveryTopPlane
R100_1000 100 1000 2.001600e-02
L1000_1000000001 1000 1000000001 3.600000e-11
R100_1001 100 1001 2.001600e-02
L1001_1000002001 1001 1000002001 3.600000e-11
R100_1002 100 1002 2.001600e-02
L1002_1000004001 1002 1000004001 3.600000e-11
R100_1003 100 1003 2.001600e-02
L1003_1002000001 1003 1002000001 3.600000e-11
R100_1004 100 1004 2.001600e-02
L1004_1002002001 1004 1002002001 3.600000e-11
R100_1005 100 1005 2.001600e-02
L1005_1002004001 1005 1002004001 3.600000e-11
*PowerDeliveryBottomPlane
R0_2000 0 2000 2.001600e-02
L2000_1000000002 2000 1000000002 3.600000e-11
R0_2001 0 2001 2.001600e-02
L2001_1000002002 2001 1000002002 3.600000e-11
R0_2002 0 2002 2.001600e-02
L2002_1000004002 2002 1000004002 3.600000e-11
R0_2003 0 2003 2.001600e-02
L2003_1002000002 2003 1002000002 3.600000e-11
R0_2004 0 2004 2.001600e-02
L2004_1002002002 2004 1002002002 3.600000e-11
R0_2005 0 2005 2.001600e-02
L2005_1002004002 2005 1002004002 3.600000e-11
*Load
C1000000001_1000000002 1000000001 1000000002 12.305556e-09
C1000002001_1000002002 1000002001 1000002002 1012.305556e-09
C1000004001_1000004002 1000004001 1000004002 12.305556e-09
C1002000001_1002000002 1002000001 1002000002 12.305556e-09
C1002002001_1002002002 1002002001 1002002002 12.305556e-09
C1002004001_1002004002 1002004001 1002004002 12.305556e-09
I1000000001_1000000002 1000000001 1000000002 DC 5
I1000002001_1000002002 1000002001 1000002002 DC 5
I1000004001_1000004002 1000004001 1000004002 DC 5
I1002000001_1002000002 1002000001 1002000002 DC 5
I1002002001_1002002002 1002002001 1002002002 DC 5
I1002004001_1002004002 1002004001 1002004002 DC 5

*Source
VIN 60 0 DC 3.3

*PCB and Package
R60_70 60 70 0.1e-3
L70_80 70 80 21e-12
R0_71 0 71 0.1e-3
L71_82 71 82 21e-12
R80_81 80 81 0.27e-3
C81_82 81 82 240e-6
R80_90 80 90 0.55e-3
L90_100 90 100 60e-12
R82_91 82 91 0.27e-3
L91_103 91 103 60e-12
R100_101 100 101 10e-3
L101_102 101 102 2.8e-12
C102_103 102 103 52e-6

.option trtol=1 sparse method=gear reltol=1m

.tran 14PS 100US uic

.END

GPUVoltageStackingPDN.cir

*On-Chip-1st-Plane

*0 line

R1000000001_1000001001 1000000001 1000001001 2.500000e-02
L1000001001_1000002001 1000001001 1000002001 2.911707e-15
R1000002001_1000003001 1000002001 1000003001 2.500000e-02
L1000003001_1000004001 1000003001 1000004001 2.911707e-15

*1st line

R1000000001_1001000001 1000000001 1001000001 2.500000e-02
L1001000001_1002000001 1001000001 1002000001 2.911707e-15
R1000002001_1001002001 1000002001 1001002001 2.500000e-02
L1001002001_1002002001 1001002001 1002002001 2.911707e-15
R1000004001_1001004001 1000004001 1001004001 2.500000e-02
L1001004001_1002004001 1001004001 1002004001 2.911707e-15

R1002000001_1002001001 1002000001 1002001001 2.500000e-02
L1002001001_1002002001 1002001001 1002002001 2.911707e-15
R1002002001_1002003001 1002002001 1002003001 2.500000e-02
L1002003001_1002004001 1002003001 1002004001 2.911707e-15

*2nd line

R1002000001_1003000001 1002000001 1003000001 2.500000e-02
L1003000001_1004000001 1003000001 1004000001 2.911707e-15
R1002002001_1003002001 1002002001 1003002001 2.500000e-02
L1003002001_1004002001 1003002001 1004002001 2.911707e-15
R1002004001_1003004001 1002004001 1003004001 2.500000e-02
L1003004001_1004004001 1003004001 1004004001 2.911707e-15

R1004000001_1004001001 1004000001 1004001001 2.500000e-02
L1004001001_1004002001 1004001001 1004002001 2.911707e-15
R1004002001_1004003001 1004002001 1004003001 2.500000e-02
L1004003001_1004004001 1004003001 1004004001 2.911707e-15

*3rd line

R1004000001_1005000001 1004000001 1005000001 2.500000e-02
L1005000001_1006000001 1005000001 1006000001 2.911707e-15
R1004002001_1005002001 1004002001 1005002001 2.500000e-02
L1005002001_1006002001 1005002001 1006002001 2.911707e-15
R1004004001_1005004001 1004004001 1005004001 2.500000e-02
L1005004001_1006004001 1005004001 1006004001 2.911707e-15

R1006000001_1006001001 1006000001 1006001001 2.500000e-02
L1006001001_1006002001 1006001001 1006002001 2.911707e-15
R1006002001_1006003001 1006002001 1006003001 2.500000e-02
L1006003001_1006004001 1006003001 1006004001 2.911707e-15

*4th line

R1006000001_1007000001 1006000001 1007000001 2.500000e-02
L1007000001_1008000001 1007000001 1008000001 2.911707e-15
R1006002001_1007002001 1006002001 1007002001 2.500000e-02
L1007002001_1008002001 1007002001 1008002001 2.911707e-15
R1006004001_1007004001 1006004001 1007004001 2.500000e-02
L1007004001_1008004001 1007004001 1008004001 2.911707e-15

R1008000001_1008001001 1008000001 1008001001 2.500000e-02
L1008001001_1008002001 1008001001 1008002001 2.911707e-15
R1008002001_1008003001 1008002001 1008003001 2.500000e-02
L1008003001_1008004001 1008003001 1008004001 2.911707e-15

*On-Chip-2nd-Plane
R1000000002_1000001002 1000000002 1000001002 2.500000e-02
L1000001002_1000002002 1000001002 1000002002 2.911707e-15
R1000002002_1000003002 1000002002 1000003002 2.500000e-02
L1000003002_1000004002 1000003002 1000004002 2.911707e-15

R1000000002_1001000002 1000000002 1001000002 2.500000e-02
L1001000002_1002000002 1001000002 1002000002 2.911707e-15
R1000002002_1001002002 1000002002 1001002002 2.500000e-02
L1001002002_1002002002 1001002002 1002002002 2.911707e-15
R1000004002_1001004002 1000004002 1001004002 2.500000e-02
L1001004002_1002004002 1001004002 1002004002 2.911707e-15

R1002000002_1002001002 1002000002 1002001002 2.500000e-02
L1002001002_1002002002 1002001002 1002002002 2.911707e-15
R1002002002_1002003002 1002002002 1002003002 2.500000e-02
L1002003002_1002004002 1002003002 1002004002 2.911707e-15

*2nd line

R1002000002_1003000002 1002000002 1003000002 2.500000e-02
L1003000002_1004000002 1003000002 1004000002 2.911707e-15
R1002002002_1003002002 1002002002 1003002002 2.500000e-02
L1003002002_1004002002 1003002002 1004002002 2.911707e-15
R1002004002_1003004002 1002004002 1003004002 2.500000e-02
L1003004002_1004004002 1003004002 1004004002 2.911707e-15

R1004000002_1004001002 1004000002 1004001002 2.500000e-02
L1004001002_1004002002 1004001002 1004002002 2.911707e-15
R1004002002_1004003002 1004002002 1004003002 2.500000e-02
L1004003002_1004004002 1004003002 1004004002 2.911707e-15

*3rd line

R1004000002_1005000002 1004000002 1005000002 2.500000e-02
L1005000002_1006000002 1005000002 1006000002 2.911707e-15
R1004002002_1005002002 1004002002 1005002002 2.500000e-02
L1005002002_1006002002 1005002002 1006002002 2.911707e-15
R1004004002_1005004002 1004004002 1005004002 2.500000e-02
L1005004002_1006004002 1005004002 1006004002 2.911707e-15

R1006000002_1006001002 1006000002 1006001002 2.500000e-02
L1006001002_1006002002 1006001002 1006002002 2.911707e-15
R1006002002_1006003002 1006002002 1006003002 2.500000e-02
L1006003002_1006004002 1006003002 1006004002 2.911707e-15

*4th line

R1006000002_1007000002 1006000002 1007000002 2.500000e-02
L1007000002_1008000002 1007000002 1008000002 2.911707e-15
R1006002002_1007002002 1006002002 1007002002 2.500000e-02
L1007002002_1008002002 1007002002 1008002002 2.911707e-15
R1006004002_1007004002 1006004002 1007004002 2.500000e-02
L1007004002_1008004002 1007004002 1008004002 2.911707e-15

R1008000002_1008001002 1008000002 1008001002 2.500000e-02
L1008001002_1008002002 1008001002 1008002002 2.911707e-15
R1008002002_1008003002 1008002002 1008003002 2.500000e-02
L1008003002_1008004002 1008003002 1008004002 2.911707e-15

*Power-Delivery-for-1st-plane
* 0 line
R100_1000 100 1000 2.001600e-02
L1000_1000000001 1000 1000000001 3.600000e-11
R100_1001 100 1001 2.001600e-02
L1001_1000002001 1001 1000002001 3.600000e-11
R100_1002 100 1002 2.001600e-02
L1002_1000004001 1002 1000004001 3.600000e-11

* 1st line

R100_1003 100 1003 2.001600e-02
L1003_1002000001 1003 1002000001 3.600000e-11
R100_1004 100 1004 2.001600e-02
L1004_1002002001 1004 1002002001 3.600000e-11
R100_1005 100 1005 2.001600e-02
L1005_1002004001 1005 1002004001 3.600000e-11

* 2nd line

R100_1006 100 1006 2.001600e-02
L1006_1004000001 1006 1004000001 3.600000e-11
R100_1007 100 1007 2.001600e-02
L1007_1004002001 1007 1004002001 3.600000e-11
R100_1008 100 1008 2.001600e-02
L1008_1004004001 1008 1004004001 3.600000e-11

* 3rd line

R100_1009 100 1009 2.001600e-02
L1009_1006000001 1009 1006000001 3.600000e-11
R100_1010 100 1010 2.001600e-02
L1010_1006002001 1010 1006002001 3.600000e-11
R100_1011 100 1011 2.001600e-02
L1011_1006004001 1011 1006004001 3.600000e-11

* 4th line

R100_1012 100 1012 2.001600e-02
L1012_1008000001 1012 1008000001 3.600000e-11
R100_1013 100 1013 2.001600e-02
L1013_1008002001 1013 1008002001 3.600000e-11
R100_1014 100 1014 2.001600e-02
L1014_1008004001 1014 1008004001 3.600000e-11

*Load-Between-1st-2nd-plane
C1000000001_1000000002 1000000001 1000000002 12.305556e-09
C1000002001_1000002002 1000002001 1000002002 12.305556e-09
C1000004001_1000004002 1000004001 1000004002 12.305556e-09

C1002000001_1002000002 1002000001 1002000002 12.305556e-09
C1002002001_1002002002 1002002001 1002002002 12.305556e-09
C1002004001_1002004002 1002004001 1002004002 12.305556e-09

C1004000001_1004000002 1004000001 1004000002 12.305556e-09
C1004002001_1004002002 1004002001 1004002002 12.305556e-09
C1004004001_1004004002 1004004001 1004004002 12.305556e-09

C1006000001_1006000002 1006000001 1006000002 12.305556e-09
C1006002001_1006002002 1006002001 1006002002 12.305556e-09
C1006004001_1006004002 1006004001 1006004002 12.305556e-09

C1008000001_1008000002 1008000001 1008000002 12.305556e-09
C1008002001_1008002002 1008002001 1008002002 12.305556e-09
C1008004001_1008004002 1008004001 1008004002 12.305556e-09

I1000000001_1000000002 1000000001 1000000002 DC 5
I1000002001_1000002002 1000002001 1000002002 DC 5
I1000004001_1000004002 1000004001 1000004002 DC 5

I1002000001_1002000002 1002000001 1002000002 DC 5
I1002002001_1002002002 1002002001 1002002002 DC 5
I1002004001_1002004002 1002004001 1002004002 DC 5

I1004000001_1004000002 1004000001 1004000002 DC 5
I1004002001_1004002002 1004002001 1004002002 DC 5
I1004004001_1004004002 1004004001 1004004002 DC 5

I1006000001_1006000002 1006000001 1006000002 DC 5
I1006002001_1006002002 1006002001 1006002002 DC 5
I1006004001_1006004002 1006004001 1006004002 DC 5

I1008000001_1008000002 1008000001 1008000002 DC 5
I1008002001_1008002002 1008002001 1008002002 DC 5
I1008004001_1008004002 1008004001 1008004002 DC 5

*Power-Delivery-for-2nd-plane
R0_2000 0 2000 2.001600e-02
L2000_1000000002 2000 1000000002 3.600000e-11
R0_2001 0 2001 2.001600e-02
L2001_1000002002 2001 1000002002 3.600000e-11
R0_2002 0 2002 2.001600e-02
L2002_1000004002 2002 1000004002 3.600000e-11

R0_2003 0 2003 2.001600e-02
L2003_1002000002 2003 1002000002 3.600000e-11
R0_2004 0 2004 2.001600e-02
L2004_1002002002 2004 1002002002 3.600000e-11
R0_2005 0 2005 2.001600e-02
L2005_1002004002 2005 1002004002 3.600000e-11

* 2nd line

R0_2006 0 2006 2.001600e-02
L2006_1004000002 2006 1004000002 3.600000e-11
R0_2007 0 2007 2.001600e-02
L2006_1004002002 2007 1004002002 3.600000e-11
R0_2008 0 2008 2.001600e-02
L2008_1004004002 2008 1004004002 3.600000e-11

* 3rd line

R0_2009 0 2009 2.001600e-02
L2009_1006000002 2009 1006000002 3.600000e-11
R0_2010 0 2010 2.001600e-02
L2010_1006002002 2010 1006002002 3.600000e-11
R0_2011 0 2011 2.001600e-02
L2011_1006004002 2011 1006004002 3.600000e-11

* 4th line

R0_2012 0 2012 2.001600e-02
L2012_1008000002 2012 1008000002 3.600000e-11
R0_2013 0 2013 2.001600e-02
L2013_1008002002 2010 1008002002 3.600000e-11
R0_2014 0 2014 2.001600e-02
L2014_1008004002 2014 1008004002 3.600000e-11

*Source
VIN 60 0 DC 1.1

*PCB and Package
R60_70 60 70 0.1e-3
L70_80 70 80 21e-12
R0_71 0 71 0.1e-3
L71_82 71 82 21e-12
R80_81 80 81 0.27e-3
C81_82 81 82 240e-6
R80_90 80 90 0.55e-3
L90_100 90 100 60e-12
R82_91 82 91 0.27e-3
L91_103 91 103 60e-12
R100_101 100 101 10e-3
L101_102 101 102 2.8e-12
C102_103 102 103 52e-6

.option trtol=1 sparse method=gear reltol=1m

.tran 14PS 100US uic

.END

DISGPUVoltageStackingPDN.cir

*On-Chip-1st-Plane
R1000000001_1000001001 1000000001 1000001001 2.500000e-02
L1000001001_1000002001 1000001001 1000002001 2.911707e-15
R1000002001_1000003001 1000002001 1000003001 2.500000e-02
L1000003001_1000004001 1000003001 1000004001 2.911707e-15
R1000000001_1001000001 1000000001 1001000001 2.500000e-02
L1001000001_1002000001 1001000001 1002000001 2.911707e-15
R1000002001_1001002001 1000002001 1001002001 2.500000e-02
L1001002001_1002002001 1001002001 1002002001 2.911707e-15
R1000004001_1001004001 1000004001 1001004001 2.500000e-02
L1001004001_1002004001 1001004001 1002004001 2.911707e-15

*On-Chip-2nd-Plane
R1000000002_1000001002 1000000002 1000001002 2.500000e-02
L1000001002_1000002002 1000001002 1000002002 2.911707e-15
R1000002002_1000003002 1000002002 1000003002 2.500000e-02
L1000003002_1000004002 1000003002 1000004002 2.911707e-15
R1000000002_1001000002 1000000002 1001000002 2.500000e-02
L1001000002_1002000002 1001000002 1002000002 2.911707e-15
R1000002002_1001002002 1000002002 1001002002 2.500000e-02
L1001002002_1002002002 1001002002 1002002002 2.911707e-15
R1000004002_1001004002 1000004002 1001004002 2.500000e-02
L1001004002_1002004002 1001004002 1002004002 2.911707e-15

*On-Chip-3rd-Plane
R1000000003_1000001003 1000000003 1000001003 2.500000e-02
L1000001003_1000002003 1000001003 1000002003 2.911707e-15
R1000002003_1000003003 1000002003 1000003003 2.500000e-02
L1000003003_1000004003 1000003003 1000004003 2.911707e-15
R1000000003_1001000003 1000000003 1001000003 2.500000e-02
L1001000003_1002000003 1001000003 1002000003 2.911707e-15
R1000002003_1001002003 1000002003 1001002003 2.500000e-02
L1001002003_1002002003 1001002003 1002002003 2.911707e-15
R1000004003_1001004003 1000004003 1001004003 2.500000e-02
L1001004003_1002004003 1001004003 1002004003 2.911707e-15

*On-Chip-4th-Plane
R1000000004_1000001004 1000000004 1000001004 2.500000e-02
L1000001004_1000002004 1000001004 1000002004 2.911707e-15
R1000002004_1000003004 1000002004 1000003004 2.500000e-02
L1000003004_1000004004 1000003004 1000004004 2.911707e-15
R1000000004_1001000004 1000000004 1001000004 2.500000e-02
L1001000004_1002000004 1001000004 1002000004 2.911707e-15
R1000002004_1001002004 1000002004 1001002004 2.500000e-02
L1001002004_1002002004 1001002004 1002002004 2.911707e-15
R1000004004_1001004004 1000004004 1001004004 2.500000e-02
L1001004004_1002004004 1001004004 1002004004 2.911707e-15

*Power-Delivery-for-1st-plane
R100_1000 100 1000 2.001600e-02
L1000_1000000001 1000 1000000001 3.600000e-11
R100_1001 100 1001 2.001600e-02
L1001_1000002001 1001 1000002001 3.600000e-11
R100_1002 100 1002 2.001600e-02
L1002_1000004001 1002 1000004001 3.600000e-11
R100_1003 100 1003 2.001600e-02
L1003_1002000001 1003 1002000001 3.600000e-11
R100_1004 100 1004 2.001600e-02
L1004_1002002001 1004 1002002001 3.600000e-11
R100_1005 100 1005 2.001600e-02
L1005_1002004001 1005 1002004001 3.600000e-11

*Load-Between-1st-2nd-plane
C1000000001_1000000002 1000000001 1000000002 12.305556e-09
C1000002001_1000002002 1000002001 1000002002 12.305556e-09
C1000004001_1000004002 1000004001 1000004002 12.305556e-09
C1002000001_1002000002 1002000001 1002000002 12.305556e-09
C1002002001_1002002002 1002002001 1002002002 12.305556e-09
C1002004001_1002004002 1002004001 1002004002 12.305556e-09
I1000000001_1000000002 1000000001 1000000002 DC 5
I1000002001_1000002002 1000002001 1000002002 DC 5
I1000004001_1000004002 1000004001 1000004002 DC 5
I1002000001_1002000002 1002000001 1002000002 DC 5
I1002002001_1002002002 1002002001 1002002002 DC 5
I1002004001_1002004002 1002004001 1002004002 DC 5

*Load-Between-2nd-3rd-plane
C1000000002_1000000003 1000000002 1000000003 12.305556e-09
C1000002002_1000002003 1000002002 1000002003 12.305556e-09
C1000004002_1000004003 1000004002 1000004003 12.305556e-09
C1002000002_1002000003 1002000002 1002000003 12.305556e-09
C1002002002_1002002003 1002002002 1002002003 12.305556e-09
C1002004002_1002004003 1002004002 1002004003 12.305556e-09
I1000000002_1000000003 1000000002 1000000003 DC 5
I1000002002_1000002003 1000002002 1000002003 DC 5
I1000004002_1000004003 1000004002 1000004003 DC 5
I1002000002_1002000003 1002000002 1002000003 DC 5
I1002002002_1002002003 1002002002 1002002003 DC 5
I1002004002_1002004003 1002004002 1002004003 DC 5

*Load-Between-3rd-4th-plane
C1000000003_1000000004 1000000003 1000000004 12.305556e-09
C1000002003_1000002004 1000002003 1000002004 12.305556e-09
C1000004003_1000004004 1000004003 1000004004 12.305556e-09
C1002000003_1002000004 1002000003 1002000004 12.305556e-09
C1002002003_1002002004 1002002003 1002002004 12.305556e-09
C1002004003_1002004004 1002004003 1002004004 12.305556e-09
I1000000003_1000000004 1000000003 1000000004 DC 5
I1000002003_1000002004 1000002003 1000002004 DC 5
I1000004003_1000004004 1000004003 1000004004 DC 5
I1002000003_1002000004 1002000003 1002000004 DC 5
I1002002003_1002002004 1002002003 1002002004 DC 5
I1002004003_1002004004 1002004003 1002004004 DC 5

*Power-Delivery-for-4th-plane
R0_2000 0 2000 2.001600e-02
L2000_1000000004 2000 1000000004 3.600000e-11
R0_2001 0 2001 2.001600e-02
L2001_1000002004 2001 1000002004 3.600000e-11
R0_2002 0 2002 2.001600e-02
L2002_1000004004 2002 1000004004 3.600000e-11
R0_2003 0 2003 2.001600e-02
L2003_1002000004 2003 1002000004 3.600000e-11
R0_2004 0 2004 2.001600e-02
L2004_1002002004 2004 1002002004 3.600000e-11
R0_2005 0 2005 2.001600e-02
L2005_1002004004 2005 1002004004 3.600000e-11

.MODEL switch1 SW (RON=0.001 ROFF=1e3 VT=0.99 VH=0)

*SM1 IVR
*Phase-1-Switches
switch1_1_1 1000000001 30000011 phase1 0 switch1 off
R1_1_1 30000011 3000001 1e-3
switch1_1_2 1000000002 30010011 phase1 0 switch1 off
R1_1_2 30010011 3001001 1e-3
switch1_1_3 1000000003 30020011 phase1 0 switch1 off
R1_1_3 30020011 3002001 1e-3
switch1_1_4 1000000002 40000011 phase1 0 switch1 off
R1_1_4 40000011 4000001 1e-3
switch1_1_5 1000000003 40010011 phase1 0 switch1 off
R1_1_5 40010011 4001001 1e-3
switch1_1_6 1000000004 40020011 phase1 0 switch1 off
R1_1_6 40020011 4002001 1e-3
*Phase-2-Switches
switch1_2_1 1000000002 30000011 phase2 0 switch1 off
R1_2_1 30000011 3000001 1e-3
switch1_2_2 1000000003 30010011 phase2 0 switch1 off
R1_2_2 30010011 3001001 1e-3
switch1_2_3 1000000004 30020011 phase2 0 switch1 off
R1_2_3 30020011 3002001 1e-3
switch1_2_4 1000000001 40000011 phase2 0 switch1 off
R1_2_4 40000011 4000001 1e-3
switch1_2_5 1000000002 40010011 phase2 0 switch1 off
R1_2_5 40010011 4001001 1e-3
switch1_2_6 1000000003 40020011 phase2 0 switch1 off
R1_2_6 40020011 4002001 1e-3
*Left-Capacitors
C3000001_3001001 3000001 3001001 1.001e-6
C3001001_3002001 3001001 3002001 1.001e-6
*Right-Capacitor
C4000001_4001001 4000001 4001001 1.001e-6
C4001001_4002001 4001001 4002001 1.001e-6

*SM2 IVR
*Phase-1-Switches
switch2_1_1 1000002001 30000021 phase1 0 switch1 off
R2_1_1 30000021 3000002 1e-3
switch2_1_2 1000002002 30010021 phase1 0 switch1 off
R2_1_2 30010021 3001002 1e-3
switch2_1_3 1000002003 30020021 phase1 0 switch1 off
R2_1_3 30020021 3002002 1e-3
switch2_1_4 1000002002 40000021 phase1 0 switch1 off
R2_1_4 40000021 4000002 1e-3
switch2_1_5 1000002003 40010021 phase1 0 switch1 off
R2_1_5 40010021 4001002 1e-3
switch2_1_6 1000002004 40020021 phase1 0 switch1 off
R2_1_6 40020021 4002002 1e-3
*Phase-2-Switches
switch2_2_1 1000002002 30000021 phase2 0 switch1 off
R2_2_1 30000021 3000002 1e-3
switch2_2_2 1000002003 30010021 phase2 0 switch1 off
R2_2_2 30010021 3001002 1e-3
switch2_2_3 1000002004 30020021 phase2 0 switch1 off
R2_2_3 30020021 3002002 1e-3
switch2_2_4 1000002001 40000021 phase2 0 switch1 off
R2_2_4 40000021 4000002 1e-3
switch2_2_5 1000002002 40010021 phase2 0 switch1 off
R2_2_5 40010021 4001002 1e-3
R2_2_6 40020021 4002002 1e-3
switch2_2_6 1000002003 40020021 phase2 0 switch1 off
*Left-Capacitors
C3000002_3001002 3000002 3001002 1.001e-6
C3001002_3002002 3001002 3002002 1.001e-6
*Right-Capacitors
C4000002_4001002 4000002 4001002 1.001e-6
C4001002_4002002 4001002 4002002 1.001e-6

*SM3 IVR
*Phase-1-Switches
switch3_1_1 1000004001 30000031 phase1 0 switch1 off
R3_1_1 30000031 3000003 1e-3
switch3_1_2 1000004002 30010031 phase1 0 switch1 off
R3_1_2 30010031 3001003 1e-3
switch3_1_3 1000004003 30020031 phase1 0 switch1 off
R3_1_3 30020031 3002003 1e-3
switch3_1_4 1000004002 40000031 phase1 0 switch1 off
R3_1_4 40000031 4000003 1e-3
switch3_1_5 1000004003 40010031 phase1 0 switch1 off
R3_1_5 40010031 4001003 1e-3
switch3_1_6 1000004004 40020031 phase1 0 switch1 off
R3_1_6 40020031 4002003 1e-3
*Phase-2-Switches
switch3_2_1 1000004002 30000031 phase2 0 switch1 off
R3_2_1 30000031 3000003 1e-3
switch3_2_2 1000004003 30010031 phase2 0 switch1 off
R3_2_2 30010031 3001003 1e-3
switch3_2_3 1000004004 30020031 phase2 0 switch1 off
R3_2_3 30020031 3002003 1e-3
switch3_2_4 1000004001 40000031 phase2 0 switch1 off
R3_2_4 40000031 4000003 1e-3
switch3_2_5 1000004002 40010031 phase2 0 switch1 off
R3_2_5 40010031 4001003 1e-3
switch3_2_6 1000004003 40020031 phase2 0 switch1 off
R3_2_6 40020031 4002003 1e-3
*Left-Capacitors
C3000003_3001003 3000003 3001003 1.001e-6
C3001003_3002003 3001003 3002003 1.001e-6
*Right-Capacitors
C4000003_4001003 4000003 4001003 1.001e-6
C4001003_4002003 4001003 4002003 1.001e-6

*SM4 IVR
*Phase-1-Switches
switch4_1_1 1002000001 30000041 phase1 0 switch1 off
R4_1_1 30000041 3000004 1e-3
switch4_1_2 1002000002 30010041 phase1 0 switch1 off
R4_1_2 30010041 3001004 1e-3
switch4_1_3 1002000003 30020041 phase1 0 switch1 off
R4_1_3 30020041 3002004 1e-3
switch4_1_4 1002000002 40000041 phase1 0 switch1 off
R4_1_4 40000041 4000004 1e-3
switch4_1_5 1002000003 40010041 phase1 0 switch1 off
R4_1_5 40010041 4001004 1e-3
switch4_1_6 1002000004 40020041 phase1 0 switch1 off
R4_1_6 40020041 4002004 1e-3
*Phase-2-Switches
switch4_2_1 1002000002 30000041 phase2 0 switch1 off
R4_2_1 30000041 3000004 1e-3
switch4_2_2 1002000003 30010041 phase2 0 switch1 off
R4_2_2 30010041 3001004 1e-3
switch4_2_3 1002000004 30020041 phase2 0 switch1 off
R4_2_3 30020041 3002004 1e-3
switch4_2_4 1002000001 40000041 phase2 0 switch1 off
R4_2_4 40000041 4000004 1e-3
switch4_2_5 1002000002 40010041 phase2 0 switch1 off
R4_2_5 40010041 4001004 1e-3
switch4_2_6 1002000003 40020041 phase2 0 switch1 off
R4_2_6 40020041 4002004 1e-3
*Left-Capacitors
C3000004_3001004 3000004 3001004 1.001e-6
C3001004_3002004 3001004 3002004 1.001e-6
*Right-Capacitors
C4000004_4001004 4000004 4001004 1.001e-6
C4001004_4002004 4001004 4002004 1.001e-6

*SM5 IVR
*Phase-1-Switches
switch5_1_1 1002002001 30000051 phase1 0 switch1 off
R5_1_1 30000051 3000005 1e-3
switch5_1_2 1002002002 30010051 phase1 0 switch1 off
R5_1_2 30010051 3001005 1e-3
switch5_1_3 1002002003 30020051 phase1 0 switch1 off
R5_1_3 30020051 3002005 1e-3
switch5_1_4 1002002002 40000051 phase1 0 switch1 off
R5_1_4 40000051 4000005 1e-3
switch5_1_5 1002002003 40010051 phase1 0 switch1 off
R5_1_5 40010051 4001005 1e-3
switch5_1_6 1002002004 40020051 phase1 0 switch1 off
R5_1_6 40020051 4002005 1e-3
*Phase-2-Switches
switch5_2_1 1002002002 30000051 phase2 0 switch1 off
R5_2_1 30000051 3000005 1e-3
switch5_2_2 1002002003 30010051 phase2 0 switch1 off
R5_2_2 30010051 3001005 1e-3
switch5_2_3 1002002004 30020051 phase2 0 switch1 off
R5_2_3 30020051 3002005 1e-3
switch5_2_4 1002002001 40000051 phase2 0 switch1 off
R5_2_4 40000051 4000005 1e-3
switch5_2_5 1002002002 40010051 phase2 0 switch1 off
R5_2_5 40010051 4001005 1e-3
switch5_2_6 1002002003 40020051 phase2 0 switch1 off
R5_2_6 40020051 4002005 1e-3
*Left-Capacitors
C3000005_3001005 3000005 3001005 1.001e-6
C3001005_3002005 3001005 3002005 1.001e-6
*Right-Capacitors
C4000005_4001005 4000005 4001005 1.001e-6
C4001005_4002005 4001005 4002005 1.001e-6

*SM6 IVR
*Phase-1-Switches
*switch6_1_1 1002004001 30000061 phase1 0 switch1 off
*R6_1_1 30000061 3000006 1e-3
*switch6_1_2 1002004002 30010061 phase1 0 switch1 off
*R6_1_2 30010061 3001006 1e-3
*switch6_1_3 1002004003 30020061 phase1 0 switch1 off
*R6_1_3 30020061 3002006 1e-3
*switch6_1_4 1002004002 40000061 phase1 0 switch1 off
*R6_1_4 40000061 4000006 1e-30
*switch6_1_5 1002004003 40010061 phase1 0 switch1 off
*R6_1_5 40010061 4001006 1e-3
*switch6_1_6 1002004004 40020061 phase1 0 switch1 off
*R6_1_6 40020061 4002006 1e-3
*Phase-2-Switches
*switch6_2_1 1002004002 30000061 phase2 0 switch1 off
*R6_2_1 30000061 3000006 1e-3
*switch6_2_2 1002004003 30010061 phase2 0 switch1 off
*R6_2_2 30010061 3001006 1e-3
*switch6_2_3 1002004004 30020061 phase2 0 switch1 off
*R6_2_3 30020061 3002006 1e-3
*switch6_2_4 1002004001 40000061 phase2 0 switch1 off
*R6_2_4 40000061 4000006 1e-3
*switch6_2_5 1002004002 40010061 phase2 0 switch1 off
*R6_2_5 40010061 4001006 1e-3
*switch6_2_6 1002004003 40020061 phase2 0 switch1 off
*R6_2_6 40020061 4002006 1e-3
*Left-Capacitors
*C3000006_3001006 3000006 3001006 1.001e-6
*C3001006_3002006 3001006 3002006 1.001e-6
*Right-Capacitors
*C4000006_4001006 4000006 4001006 1.001e-6
*C4001006_4002006 4001006 4002006 1.001e-6

V_phase1 phase1 0 pulse(0 1 0 1ps 1ps 5ns 10ns)
V_phase2 phase2 0 pulse(0 1 5ns 1ps 1ps 5ns 10ns)

*Source
VIN 60 0 DC 3.3

*PCB and Package
R60_70 60 70 0.1e-3
L70_80 70 80 21e-12
R0_71 0 71 0.1e-3
L71_82 71 82 21e-12
R80_81 80 81 0.27e-3
C81_82 81 82 240e-6
R80_90 80 90 0.55e-3
L90_100 90 100 60e-12
R82_91 82 91 0.27e-3
L91_103 91 103 60e-12
R100_101 100 101 10e-3
L101_102 101 102 2.8e-12
C102_103 102 103 52e-6

.option trtol=1 sparse method=gear reltol=1m

.tran 14PS 100US uic

.END

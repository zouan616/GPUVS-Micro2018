4x4GPUVSPDN.cir

*1st-Plane-top-plate
*SM1
R1000000001_1000001001 1000000001 1000001001 2.500000e-02
L1000001001_1000002001 1000001001 1000002001 2.911707e-15
R1000002001_1000003001 1000002001 1000003001 2.500000e-02
L1000003001_1000004001 1000003001 1000004001 2.911707e-15

R1000000001_1001000001 1000000001 1001000001 2.500000e-02
L1001000001_1002000001 1001000001 1002000001 2.911707e-15
R1000002001_1001002001 1000002001 1001002001 2.500000e-02
L1001002001_1002002001 1001002001 1002002001 2.911707e-15
R1000004001_1001004001 1000004001 1001004001 2.500000e-02
L1001004001_1002004001 1001004001 1002004001 2.911707e-15

R1002000001_1002001001 1002000001 1002001001 2.500000e-02
L1002001001_1002002001 1002001001 1002002001 2.911707e-15
R1002002001_1002003001 1002002001 1002003001 2.500000e-02
L1002003001_1002004001 1002003001 1002004001 2.911707e-15

*Connection between SM1 and SM2
R1000004001_1000005001 1000004001 1000005001 2.500000e-02
L1000005001_1000006001 1000005001 1000006001 2.911707e-15
R1002004001_1002005001 1002004001 1002005001 2.500000e-02
L1002005001_1002006001 1002005001 1002006001 2.911707e-15

*SM2
R1000006001_1000007001 1000006001 1000007001 2.500000e-02
L1000007001_1000008001 1000007001 1000008001 2.911707e-15
R1000008001_1000009001 1000008001 1000009001 2.500000e-02
L1000009001_1000010001 1000009001 1000010001 2.911707e-15

R1000006001_1001006001 1000006001 1001006001 2.500000e-02
L1001006001_1002006001 1001006001 1002006001 2.911707e-15
R1000008001_1001008001 1000008001 1001008001 2.500000e-02
L1001008001_1002008001 1001008001 1002008001 2.911707e-15
R1000010001_1001010001 1000010001 1001010001 2.500000e-02
L1001010001_1002010001 1001010001 1002010001 2.911707e-15

R1002006001_1002007001 1002006001 1002007001 2.500000e-02
L1002007001_1002008001 1002007001 1002008001 2.911707e-15
R1002008001_1002009001 1002008001 1002009001 2.500000e-02
L1002009001_1002010001 1002009001 1002010001 2.911707e-15

*Connection between SM2 and SM3
R1000010001_1000011001 1000010001 1000011001 2.500000e-02
L1000011001_1000012001 1000011001 1000012001 2.911707e-15
R1002010001_1002011001 1002010001 1002011001 2.500000e-02
L1002011001_1002012001 1002011001 1002012001 2.911707e-15

*SM3
R1000012001_1000013001 1000012001 1000013001 2.500000e-02
L1000013001_1000014001 1000013001 1000014001 2.911707e-15
R1000014001_1000015001 1000014001 1000015001 2.500000e-02
L1000015001_1000016001 1000015001 1000016001 2.911707e-15

R1000012001_1001012001 1000012001 1001012001 2.500000e-02
L1001012001_1002012001 1001012001 1002012001 2.911707e-15
R1000014001_1001014001 1000014001 1001014001 2.500000e-02
L1001014001_1002014001 1001014001 1002014001 2.911707e-15
R1000016001_1001016001 1000016001 1001016001 2.500000e-02
L1001016001_1002016001 1001016001 1002016001 2.911707e-15

R1002012001_1002013001 1002012001 1002013001 2.500000e-02
L1002013001_1002014001 1002013001 1002014001 2.911707e-15
R1002014001_1002015001 1002014001 1002015001 2.500000e-02
L1002015001_1002016001 1002015001 1002016001 2.911707e-15

*Connection between SM3 and SM4
R1000016001_1000017001 1000016001 1000017001 2.500000e-02
L1000017001_1000018001 1000017001 1000018001 2.911707e-15
R1002016001_1002017001 1002016001 1002017001 2.500000e-02
L1002017001_1002018001 1002017001 1002018001 2.911707e-15

*SM4
R1000018001_1000019001 1000018001 1000019001 2.500000e-02
L1000019001_1000020001 1000019001 1000020001 2.911707e-15
R1000020001_1000021001 1000020001 1000021001 2.500000e-02
L1000021001_1000022001 1000021001 1000022001 2.911707e-15

R1000018001_1001018001 1000018001 1001018001 2.500000e-02
L1001018001_1002018001 1001018001 1002018001 2.911707e-15
R1000020001_1001020001 1000020001 1001020001 2.500000e-02
L1001020001_1002020001 1001020001 1002020001 2.911707e-15
R1000022001_1001022001 1000022001 1001022001 2.500000e-02
L1001022001_1002022001 1001022001 1002022001 2.911707e-15

R1002018001_1002019001 1002018001 1002019001 2.500000e-02
L1002019001_1002020001 1002019001 1002020001 2.911707e-15
R1002020001_1002021001 1002020001 1002021001 2.500000e-02
L1002021001_1002022001 1002021001 1002022001 2.911707e-15

*1st-Plane-bottom-plate
*SM1
R1000000002_1000001002 1000000002 1000001002 2.500000e-02
L1000001002_1000002002 1000001002 1000002002 2.911707e-15
R1000002002_1000003002 1000002002 1000003002 2.500000e-02
L1000003002_1000004002 1000003002 1000004002 2.911707e-15

R1000000002_1001000002 1000000002 1001000002 2.500000e-02
L1001000002_1002000002 1001000002 1002000002 2.911707e-15
R1000002002_1001002002 1000002002 1001002002 2.500000e-02
L1001002002_1002002002 1001002002 1002002002 2.911707e-15
R1000004002_1001004002 1000004002 1001004002 2.500000e-02
L1001004002_1002004002 1001004002 1002004002 2.911707e-15

R1002000002_1002001002 1002000002 1002001002 2.500000e-02
L1002001002_1002002002 1002001002 1002002002 2.911707e-15
R1002002002_1002003002 1002002002 1002003002 2.500000e-02
L1002003002_1002004002 1002003002 1002004002 2.911707e-15

*Connection between SM1 and SM2
R1000004002_1000005002 1000004002 1000005002 2.500000e-02
L1000005002_1000006002 1000005002 1000006002 2.911707e-15
R1002004002_1002005002 1002004002 1002005002 2.500000e-02
L1002005002_1002006002 1002005002 1002006002 2.911707e-15

*SM2
R1000006002_1000007002 1000006002 1000007002 2.500000e-02
L1000007002_1000008002 1000007002 1000008002 2.911707e-15
R1000008002_1000009002 1000008002 1000009002 2.500000e-02
L1000009002_1000010002 1000009002 1000010002 2.911707e-15

R1000006002_1001006002 1000006002 1001006002 2.500000e-02
L1001006002_1002006002 1001006002 1002006002 2.911707e-15
R1000008002_1001008002 1000008002 1001008002 2.500000e-02
L1001008002_1002008002 1001008002 1002008002 2.911707e-15
R1000010002_1001010002 1000010002 1001010002 2.500000e-02
L1001010002_1002010002 1001010002 1002010002 2.911707e-15

R1002006002_1002007002 1002006002 1002007002 2.500000e-02
L1002007002_1002008002 1002007002 1002008002 2.911707e-15
R1002008002_1002009002 1002008002 1002009002 2.500000e-02
L1002009002_1002010002 1002009002 1002010002 2.911707e-15

*Connection between SM2 and SM3
R1000010002_1000011002 1000010002 1000011002 2.500000e-02
L1000011002_1000012002 1000011002 1000012002 2.911707e-15
R1002010002_1002011002 1002010002 1002011002 2.500000e-02
L1002011002_1002012002 1002011002 1002012002 2.911707e-15

*SM3
R1000012002_1000013002 1000012002 1000013002 2.500000e-02
L1000013002_1000014002 1000013002 1000014002 2.911707e-15
R1000014002_1000015002 1000014002 1000015002 2.500000e-02
L1000015002_1000016002 1000015002 1000016002 2.911707e-15

R1000012002_1001012002 1000012002 1001012002 2.500000e-02
L1001012002_1002012002 1001012002 1002012002 2.911707e-15
R1000014002_1001014002 1000014002 1001014002 2.500000e-02
L1001014002_1002014002 1001014002 1002014002 2.911707e-15
R1000016002_1001016002 1000016002 1001016002 2.500000e-02
L1001016002_1002016002 1001016002 1002016002 2.911707e-15

R1002012002_1002013002 1002012002 1002013002 2.500000e-02
L1002013002_1002014002 1002013002 1002014002 2.911707e-15
R1002014002_1002015002 1002014002 1002015002 2.500000e-02
L1002015002_1002016002 1002015002 1002016002 2.911707e-15

*Connection between SM3 and SM4
R1000016002_1000017002 1000016002 1000017002 2.500000e-02
L1000017002_1000018002 1000017002 1000018002 2.911707e-15
R1002016002_1002017002 1002016002 1002017002 2.500000e-02
L1002017002_1002018002 1002017002 1002018002 2.911707e-15

*SM4
R1000018002_1000019002 1000018002 1000019002 2.500000e-02
L1000019002_1000020002 1000019002 1000020002 2.911707e-15
R1000020002_1000021002 1000020002 1000021002 2.500000e-02
L1000021002_1000022002 1000021002 1000022002 2.911707e-15

R1000018002_1001018002 1000018002 1001018002 2.500000e-02
L1001018002_1002018002 1001018002 1002018002 2.911707e-15
R1000020002_1001020002 1000020002 1001020002 2.500000e-02
L1001020002_1002020002 1001020002 1002020002 2.911707e-15
R1000022002_1001022002 1000022002 1001022002 2.500000e-02
L1001022002_1002022002 1001022002 1002022002 2.911707e-15

R1002018002_1002019002 1002018002 1002019002 2.500000e-02
L1002019002_1002020002 1002019002 1002020002 2.911707e-15
R1002020002_1002021002 1002020002 1002021002 2.500000e-02
L1002021002_1002022002 1002021002 1002022002 2.911707e-15

*2nd-Plane-top-plate
*SM5
R1000000003_1000001003 1000000003 1000001003 2.500000e-02
L1000001003_1000002003 1000001003 1000002003 2.911707e-15
R1000002003_1000003003 1000002003 1000003003 2.500000e-02
L1000003003_1000004003 1000003003 1000004003 2.911707e-15

R1000000003_1001000003 1000000003 1001000003 2.500000e-02
L1001000003_1002000003 1001000003 1002000003 2.911707e-15
R1000002003_1001002003 1000002003 1001002003 2.500000e-02
L1001002003_1002002003 1001002003 1002002003 2.911707e-15
R1000004003_1001004003 1000004003 1001004003 2.500000e-02
L1001004003_1002004003 1001004003 1002004003 2.911707e-15

R1002000003_1002001003 1002000003 1002001003 2.500000e-02
L1002001003_1002002003 1002001003 1002002003 2.911707e-15
R1002002003_1002003003 1002002003 1002003003 2.500000e-02
L1002003003_1002004003 1002003003 1002004003 2.911707e-15

*Connection between SM5 and SM6
R1000004003_1000005003 1000004003 1000005003 2.500000e-02
L1000005003_1000006003 1000005003 1000006003 2.911707e-15
R1002004003_1002005003 1002004003 1002005003 2.500000e-02
L1002005003_1002006003 1002005003 1002006003 2.911707e-15

*SM6
R1000006003_1000007003 1000006003 1000007003 2.500000e-02
L1000007003_1000008003 1000007003 1000008003 2.911707e-15
R1000008003_1000009003 1000008003 1000009003 2.500000e-02
L1000009003_1000010003 1000009003 1000010003 2.911707e-15

R1000006003_1001006003 1000006003 1001006003 2.500000e-02
L1001006003_1002006003 1001006003 1002006003 2.911707e-15
R1000008003_1001008003 1000008003 1001008003 2.500000e-02
L1001008003_1002008003 1001008003 1002008003 2.911707e-15
R1000010003_1001010003 1000010003 1001010003 2.500000e-02
L1001010003_1002010003 1001010003 1002010003 2.911707e-15

R1002006003_1002007003 1002006003 1002007003 2.500000e-02
L1002007003_1002008003 1002007003 1002008003 2.911707e-15
R1002008003_1002009003 1002008003 1002009003 2.500000e-02
L1002009003_1002010003 1002009003 1002010003 2.911707e-15

*Connection between SM6 and SM7
R1000010003_1000011003 1000010003 1000011003 2.500000e-02
L1000011003_1000012003 1000011003 1000012003 2.911707e-15
R1002010003_1002011003 1002010003 1002011003 2.500000e-02
L1002011003_1002012003 1002011003 1002012003 2.911707e-15

*SM7
R1000012003_1000013003 1000012003 1000013003 2.500000e-02
L1000013003_1000014003 1000013003 1000014003 2.911707e-15
R1000014003_1000015003 1000014003 1000015003 2.500000e-02
L1000015003_1000016003 1000015003 1000016003 2.911707e-15

R1000012003_1001012003 1000012003 1001012003 2.500000e-02
L1001012003_1002012003 1001012003 1002012003 2.911707e-15
R1000014003_1001014003 1000014003 1001014003 2.500000e-02
L1001014003_1002014003 1001014003 1002014003 2.911707e-15
R1000016003_1001016003 1000016003 1001016003 2.500000e-02
L1001016003_1002016003 1001016003 1002016003 2.911707e-15

R1002012003_1002013003 1002012003 1002013003 2.500000e-02
L1002013003_1002014003 1002013003 1002014003 2.911707e-15
R1002014003_1002015003 1002014003 1002015003 2.500000e-02
L1002015003_1002016003 1002015003 1002016003 2.911707e-15

*Connection between SM7 and SM8
R1000016003_1000017003 1000016003 1000017003 2.500000e-02
L1000017003_1000018003 1000017003 1000018003 2.911707e-15
R1002016003_1002017003 1002016003 1002017003 2.500000e-02
L1002017003_1002018003 1002017003 1002018003 2.911707e-15

*SM8
R1000018003_1000019003 1000018003 1000019003 2.500000e-02
L1000019003_1000020003 1000019003 1000020003 2.911707e-15
R1000020003_1000021003 1000020003 1000021003 2.500000e-02
L1000021003_1000022003 1000021003 1000022003 2.911707e-15

R1000018003_1001018003 1000018003 1001018003 2.500000e-02
L1001018003_1002018003 1001018003 1002018003 2.911707e-15
R1000020003_1001020003 1000020003 1001020003 2.500000e-02
L1001020003_1002020003 1001020003 1002020003 2.911707e-15
R1000022003_1001022003 1000022003 1001022003 2.500000e-02
L1001022003_1002022003 1001022003 1002022003 2.911707e-15

R1002018003_1002019003 1002018003 1002019003 2.500000e-02
L1002019003_1002020003 1002019003 1002020003 2.911707e-15
R1002020003_1002021003 1002020003 1002021003 2.500000e-02
L1002021003_1002022003 1002021003 1002022003 2.911707e-15

*2nd-Plane-bottom-plate
*SM5
R1000000004_1000001004 1000000004 1000001004 2.500000e-02
L1000001004_1000002004 1000001004 1000002004 2.911707e-15
R1000002004_1000003004 1000002004 1000003004 2.500000e-02
L1000003004_1000004004 1000003004 1000004004 2.911707e-15

R1000000004_1001000004 1000000004 1001000004 2.500000e-02
L1001000004_1002000004 1001000004 1002000004 2.911707e-15
R1000002004_1001002004 1000002004 1001002004 2.500000e-02
L1001002004_1002002004 1001002004 1002002004 2.911707e-15
R1000004004_1001004004 1000004004 1001004004 2.500000e-02
L1001004004_1002004004 1001004004 1002004004 2.911707e-15

R1002000004_1002001004 1002000004 1002001004 2.500000e-02
L1002001004_1002002004 1002001004 1002002004 2.911707e-15
R1002002004_1002003004 1002002004 1002003004 2.500000e-02
L1002003004_1002004004 1002003004 1002004004 2.911707e-15

*Connection between SM5 and SM6
R1000004004_1000005004 1000004004 1000005004 2.500000e-02
L1000005004_1000006004 1000005004 1000006004 2.911707e-15
R1002004004_1002005004 1002004004 1002005004 2.500000e-02
L1002005004_1002006004 1002005004 1002006004 2.911707e-15

*SM6
R1000006004_1000007004 1000006004 1000007004 2.500000e-02
L1000007004_1000008004 1000007004 1000008004 2.911707e-15
R1000008004_1000009004 1000008004 1000009004 2.500000e-02
L1000009004_1000010004 1000009004 1000010004 2.911707e-15

R1000006004_1001006004 1000006004 1001006004 2.500000e-02
L1001006004_1002006004 1001006004 1002006004 2.911707e-15
R1000008004_1001008004 1000008004 1001008004 2.500000e-02
L1001008004_1002008004 1001008004 1002008004 2.911707e-15
R1000010004_1001010004 1000010004 1001010004 2.500000e-02
L1001010004_1002010004 1001010004 1002010004 2.911707e-15

R1002006004_1002007004 1002006004 1002007004 2.500000e-02
L1002007004_1002008004 1002007004 1002008004 2.911707e-15
R1002008004_1002009004 1002008004 1002009004 2.500000e-02
L1002009004_1002010004 1002009004 1002010004 2.911707e-15

*Connection between SM6 and SM7
R1000010004_1000011004 1000010004 1000011004 2.500000e-02
L1000011004_1000012004 1000011004 1000012004 2.911707e-15
R1002010004_1002011004 1002010004 1002011004 2.500000e-02
L1002011004_1002012004 1002011004 1002012004 2.911707e-15

*SM7
R1000012004_1000013004 1000012004 1000013004 2.500000e-02
L1000013004_1000014004 1000013004 1000014004 2.911707e-15
R1000014004_1000015004 1000014004 1000015004 2.500000e-02
L1000015004_1000016004 1000015004 1000016004 2.911707e-15

R1000012004_1001012004 1000012004 1001012004 2.500000e-02
L1001012004_1002012004 1001012004 1002012004 2.911707e-15
R1000014004_1001014004 1000014004 1001014004 2.500000e-02
L1001014004_1002014004 1001014004 1002014004 2.911707e-15
R1000016004_1001016004 1000016004 1001016004 2.500000e-02
L1001016004_1002016004 1001016004 1002016004 2.911707e-15

R1002012004_1002013004 1002012004 1002013004 2.500000e-02
L1002013004_1002014004 1002013004 1002014004 2.911707e-15
R1002014004_1002015004 1002014004 1002015004 2.500000e-02
L1002015004_1002016004 1002015004 1002016004 2.911707e-15

*Connection between SM7 and SM8
R1000016004_1000017004 1000016004 1000017004 2.500000e-02
L1000017004_1000018004 1000017004 1000018004 2.911707e-15
R1002016004_1002017004 1002016004 1002017004 2.500000e-02
L1002017004_1002018004 1002017004 1002018004 2.911707e-15

*SM8
R1000018004_1000019004 1000018004 1000019004 2.500000e-02
L1000019004_1000020004 1000019004 1000020004 2.911707e-15
R1000020004_1000021004 1000020004 1000021004 2.500000e-02
L1000021004_1000022004 1000021004 1000022004 2.911707e-15

R1000018004_1001018004 1000018004 1001018004 2.500000e-02
L1001018004_1002018004 1001018004 1002018004 2.911707e-15
R1000020004_1001020004 1000020004 1001020004 2.500000e-02
L1001020004_1002020004 1001020004 1002020004 2.911707e-15
R1000022004_1001022004 1000022004 1001022004 2.500000e-02
L1001022004_1002022004 1001022004 1002022004 2.911707e-15

R1002018004_1002019004 1002018004 1002019004 2.500000e-02
L1002019004_1002020004 1002019004 1002020004 2.911707e-15
R1002020004_1002021004 1002020004 1002021004 2.500000e-02
L1002021004_1002022004 1002021004 1002022004 2.911707e-15

*3rd-Plane-top-plate
*SM9
R1000000005_1000001005 1000000005 1000001005 2.500000e-02
L1000001005_1000002005 1000001005 1000002005 2.911707e-15
R1000002005_1000003005 1000002005 1000003005 2.500000e-02
L1000003005_1000004005 1000003005 1000004005 2.911707e-15

R1000000005_1001000005 1000000005 1001000005 2.500000e-02
L1001000005_1002000005 1001000005 1002000005 2.911707e-15
R1000002005_1001002005 1000002005 1001002005 2.500000e-02
L1001002005_1002002005 1001002005 1002002005 2.911707e-15
R1000004005_1001004005 1000004005 1001004005 2.500000e-02
L1001004005_1002004005 1001004005 1002004005 2.911707e-15

R1002000005_1002001005 1002000005 1002001005 2.500000e-02
L1002001005_1002002005 1002001005 1002002005 2.911707e-15
R1002002005_1002003005 1002002005 1002003005 2.500000e-02
L1002003005_1002004005 1002003005 1002004005 2.911707e-15

*Connection between SM9 and SM10
R1000004005_1000005005 1000004005 1000005005 2.500000e-02
L1000005005_1000006005 1000005005 1000006005 2.911707e-15
R1002004005_1002005005 1002004005 1002005005 2.500000e-02
L1002005005_1002006005 1002005005 1002006005 2.911707e-15

*SM10
R1000006005_1000007005 1000006005 1000007005 2.500000e-02
L1000007005_1000008005 1000007005 1000008005 2.911707e-15
R1000008005_1000009005 1000008005 1000009005 2.500000e-02
L1000009005_1000010005 1000009005 1000010005 2.911707e-15

R1000006005_1001006005 1000006005 1001006005 2.500000e-02
L1001006005_1002006005 1001006005 1002006005 2.911707e-15
R1000008005_1001008005 1000008005 1001008005 2.500000e-02
L1001008005_1002008005 1001008005 1002008005 2.911707e-15
R1000010005_1001010005 1000010005 1001010005 2.500000e-02
L1001010005_1002010005 1001010005 1002010005 2.911707e-15

R1002006005_1002007005 1002006005 1002007005 2.500000e-02
L1002007005_1002008005 1002007005 1002008005 2.911707e-15
R1002008005_1002009005 1002008005 1002009005 2.500000e-02
L1002009005_1002010005 1002009005 1002010005 2.911707e-15

*Connection between SM10 and SM11
R1000010005_1000011005 1000010005 1000011005 2.500000e-02
L1000011005_1000012005 1000011005 1000012005 2.911707e-15
R1002010005_1002011005 1002010005 1002011005 2.500000e-02
L1002011005_1002012005 1002011005 1002012005 2.911707e-15

*SM11
R1000012005_1000013005 1000012005 1000013005 2.500000e-02
L1000013005_1000014005 1000013005 1000014005 2.911707e-15
R1000014005_1000015005 1000014005 1000015005 2.500000e-02
L1000015005_1000016005 1000015005 1000016005 2.911707e-15

R1000012005_1001012005 1000012005 1001012005 2.500000e-02
L1001012005_1002012005 1001012005 1002012005 2.911707e-15
R1000014005_1001014005 1000014005 1001014005 2.500000e-02
L1001014005_1002014005 1001014005 1002014005 2.911707e-15
R1000016005_1001016005 1000016005 1001016005 2.500000e-02
L1001016005_1002016005 1001016005 1002016005 2.911707e-15

R1002012005_1002013005 1002012005 1002013005 2.500000e-02
L1002013005_1002014005 1002013005 1002014005 2.911707e-15
R1002014005_1002015005 1002014005 1002015005 2.500000e-02
L1002015005_1002016005 1002015005 1002016005 2.911707e-15

*Connection between SM11 and SM12
R1000016005_1000017005 1000016005 1000017005 2.500000e-02
L1000017005_1000018005 1000017005 1000018005 2.911707e-15
R1002016005_1002017005 1002016005 1002017005 2.500000e-02
L1002017005_1002018005 1002017005 1002018005 2.911707e-15

*SM12
R1000018005_1000019005 1000018005 1000019005 2.500000e-02
L1000019005_1000020005 1000019005 1000020005 2.911707e-15
R1000020005_1000021005 1000020005 1000021005 2.500000e-02
L1000021005_1000022005 1000021005 1000022005 2.911707e-15

R1000018005_1001018005 1000018005 1001018005 2.500000e-02
L1001018005_1002018005 1001018005 1002018005 2.911707e-15
R1000020005_1001020005 1000020005 1001020005 2.500000e-02
L1001020005_1002020005 1001020005 1002020005 2.911707e-15
R1000022005_1001022005 1000022005 1001022005 2.500000e-02
L1001022005_1002022005 1001022005 1002022005 2.911707e-15

R1002018005_1002019005 1002018005 1002019005 2.500000e-02
L1002019005_1002020005 1002019005 1002020005 2.911707e-15
R1002020005_1002021005 1002020005 1002021005 2.500000e-02
L1002021005_1002022005 1002021005 1002022005 2.911707e-15

*3rd-Plane-bottom-plate
*SM9
R1000000006_1000001006 1000000006 1000001006 2.500000e-02
L1000001006_1000002006 1000001006 1000002006 2.911707e-15
R1000002006_1000003006 1000002006 1000003006 2.500000e-02
L1000003006_1000004006 1000003006 1000004006 2.911707e-15

R1000000006_1001000006 1000000006 1001000006 2.500000e-02
L1001000006_1002000006 1001000006 1002000006 2.911707e-15
R1000002006_1001002006 1000002006 1001002006 2.500000e-02
L1001002006_1002002006 1001002006 1002002006 2.911707e-15
R1000004006_1001004006 1000004006 1001004006 2.500000e-02
L1001004006_1002004006 1001004006 1002004006 2.911707e-15

R1002000006_1002001006 1002000006 1002001006 2.500000e-02
L1002001006_1002002006 1002001006 1002002006 2.911707e-15
R1002002006_1002003006 1002002006 1002003006 2.500000e-02
L1002003006_1002004006 1002003006 1002004006 2.911707e-15

*Connection between SM9 and SM10
R1000004006_1000005006 1000004006 1000005006 2.500000e-02
L1000005006_1000006006 1000005006 1000006006 2.911707e-15
R1002004006_1002005006 1002004006 1002005006 2.500000e-02
L1002005006_1002006006 1002005006 1002006006 2.911707e-15

*SM10
R1000006006_1000007006 1000006006 1000007006 2.500000e-02
L1000007006_1000008006 1000007006 1000008006 2.911707e-15
R1000008006_1000009006 1000008006 1000009006 2.500000e-02
L1000009006_1000010006 1000009006 1000010006 2.911707e-15

R1000006006_1001006006 1000006006 1001006006 2.500000e-02
L1001006006_1002006006 1001006006 1002006006 2.911707e-15
R1000008006_1001008006 1000008006 1001008006 2.500000e-02
L1001008006_1002008006 1001008006 1002008006 2.911707e-15
R1000010006_1001010006 1000010006 1001010006 2.500000e-02
L1001010006_1002010006 1001010006 1002010006 2.911707e-15

R1002006006_1002007006 1002006006 1002007006 2.500000e-02
L1002007006_1002008006 1002007006 1002008006 2.911707e-15
R1002008006_1002009006 1002008006 1002009006 2.500000e-02
L1002009006_1002010006 1002009006 1002010006 2.911707e-15

*Connection between SM10 and SM11
R1000010006_1000011006 1000010006 1000011006 2.500000e-02
L1000011006_1000012006 1000011006 1000012006 2.911707e-15
R1002010006_1002011006 1002010006 1002011006 2.500000e-02
L1002011006_1002012006 1002011006 1002012006 2.911707e-15

*SM11
R1000012006_1000013006 1000012006 1000013006 2.500000e-02
L1000013006_1000014006 1000013006 1000014006 2.911707e-15
R1000014006_1000015006 1000014006 1000015006 2.500000e-02
L1000015006_1000016006 1000015006 1000016006 2.911707e-15

R1000012006_1001012006 1000012006 1001012006 2.500000e-02
L1001012006_1002012006 1001012006 1002012006 2.911707e-15
R1000014006_1001014006 1000014006 1001014006 2.500000e-02
L1001014006_1002014006 1001014006 1002014006 2.911707e-15
R1000016006_1001016006 1000016006 1001016006 2.500000e-02
L1001016006_1002016006 1001016006 1002016006 2.911707e-15

R1002012006_1002013006 1002012006 1002013006 2.500000e-02
L1002013006_1002014006 1002013006 1002014006 2.911707e-15
R1002014006_1002015006 1002014006 1002015006 2.500000e-02
L1002015006_1002016006 1002015006 1002016006 2.911707e-15

*Connection between SM11 and SM12
R1000016006_1000017006 1000016006 1000017006 2.500000e-02
L1000017006_1000018006 1000017006 1000018006 2.911707e-15
R1002016006_1002017006 1002016006 1002017006 2.500000e-02
L1002017006_1002018006 1002017006 1002018006 2.911707e-15

*SM12
R1000018006_1000019006 1000018006 1000019006 2.500000e-02
L1000019006_1000020006 1000019006 1000020006 2.911707e-15
R1000020006_1000021006 1000020006 1000021006 2.500000e-02
L1000021006_1000022006 1000021006 1000022006 2.911707e-15

R1000018006_1001018006 1000018006 1001018006 2.500000e-02
L1001018006_1002018006 1001018006 1002018006 2.911707e-15
R1000020006_1001020006 1000020006 1001020006 2.500000e-02
L1001020006_1002020006 1001020006 1002020006 2.911707e-15
R1000022006_1001022006 1000022006 1001022006 2.500000e-02
L1001022006_1002022006 1001022006 1002022006 2.911707e-15

R1002018006_1002019006 1002018006 1002019006 2.500000e-02
L1002019006_1002020006 1002019006 1002020006 2.911707e-15
R1002020006_1002021006 1002020006 1002021006 2.500000e-02
L1002021006_1002022006 1002021006 1002022006 2.911707e-15

*4th-Plane-top-plate
*SM13
R1000000007_1000001007 1000000007 1000001007 2.500000e-02
L1000001007_1000002007 1000001007 1000002007 2.911707e-15
R1000002007_1000003007 1000002007 1000003007 2.500000e-02
L1000003007_1000004007 1000003007 1000004007 2.911707e-15

R1000000007_1001000007 1000000007 1001000007 2.500000e-02
L1001000007_1002000007 1001000007 1002000007 2.911707e-15
R1000002007_1001002007 1000002007 1001002007 2.500000e-02
L1001002007_1002002007 1001002007 1002002007 2.911707e-15
R1000004007_1001004007 1000004007 1001004007 2.500000e-02
L1001004007_1002004007 1001004007 1002004007 2.911707e-15

R1002000007_1002001007 1002000007 1002001007 2.500000e-02
L1002001007_1002002007 1002001007 1002002007 2.911707e-15
R1002002007_1002003007 1002002007 1002003007 2.500000e-02
L1002003007_1002004007 1002003007 1002004007 2.911707e-15

*Connection between SM13 and SM14
R1000004007_1000005007 1000004007 1000005007 2.500000e-02
L1000005007_1000006007 1000005007 1000006007 2.911707e-15
R1002004007_1002005007 1002004007 1002005007 2.500000e-02
L1002005007_1002006007 1002005007 1002006007 2.911707e-15

*SM14
R1000006007_1000007007 1000006007 1000007007 2.500000e-02
L1000007007_1000008007 1000007007 1000008007 2.911707e-15
R1000008007_1000009007 1000008007 1000009007 2.500000e-02
L1000009007_1000010007 1000009007 1000010007 2.911707e-15

R1000006007_1001006007 1000006007 1001006007 2.500000e-02
L1001006007_1002006007 1001006007 1002006007 2.911707e-15
R1000008007_1001008007 1000008007 1001008007 2.500000e-02
L1001008007_1002008007 1001008007 1002008007 2.911707e-15
R1000010007_1001010007 1000010007 1001010007 2.500000e-02
L1001010007_1002010007 1001010007 1002010007 2.911707e-15

R1002006007_1002007007 1002006007 1002007007 2.500000e-02
L1002007007_1002008007 1002007007 1002008007 2.911707e-15
R1002008007_1002009007 1002008007 1002009007 2.500000e-02
L1002009007_1002010007 1002009007 1002010007 2.911707e-15

*Connection between SM14 and SM15
R1000010007_1000011007 1000010007 1000011007 2.500000e-02
L1000011007_1000012007 1000011007 1000012007 2.911707e-15
R1002010007_1002011007 1002010007 1002011007 2.500000e-02
L1002011007_1002012007 1002011007 1002012007 2.911707e-15

*SM15
R1000012007_1000013007 1000012007 1000013007 2.500000e-02
L1000013007_1000014007 1000013007 1000014007 2.911707e-15
R1000014007_1000015007 1000014007 1000015007 2.500000e-02
L1000015007_1000016007 1000015007 1000016007 2.911707e-15

R1000012007_1001012007 1000012007 1001012007 2.500000e-02
L1001012007_1002012007 1001012007 1002012007 2.911707e-15
R1000014007_1001014007 1000014007 1001014007 2.500000e-02
L1001014007_1002014007 1001014007 1002014007 2.911707e-15
R1000016007_1001016007 1000016007 1001016007 2.500000e-02
L1001016007_1002016007 1001016007 1002016007 2.911707e-15

R1002012007_1002013007 1002012007 1002013007 2.500000e-02
L1002013007_1002014007 1002013007 1002014007 2.911707e-15
R1002014007_1002015007 1002014007 1002015007 2.500000e-02
L1002015007_1002016007 1002015007 1002016007 2.911707e-15

*Connection between SM15 and SM16
R1000016007_1000017007 1000016007 1000017007 2.500000e-02
L1000017007_1000018007 1000017007 1000018007 2.911707e-15
R1002016007_1002017007 1002016007 1002017007 2.500000e-02
L1002017007_1002018007 1002017007 1002018007 2.911707e-15

*SM16
R1000018007_1000019007 1000018007 1000019007 2.500000e-02
L1000019007_1000020007 1000019007 1000020007 2.911707e-15
R1000020007_1000021007 1000020007 1000021007 2.500000e-02
L1000021007_1000022007 1000021007 1000022007 2.911707e-15

R1000018007_1001018007 1000018007 1001018007 2.500000e-02
L1001018007_1002018007 1001018007 1002018007 2.911707e-15
R1000020007_1001020007 1000020007 1001020007 2.500000e-02
L1001020007_1002020007 1001020007 1002020007 2.911707e-15
R1000022007_1001022007 1000022007 1001022007 2.500000e-02
L1001022007_1002022007 1001022007 1002022007 2.911707e-15

R1002018007_1002019007 1002018007 1002019007 2.500000e-02
L1002019007_1002020007 1002019007 1002020007 2.911707e-15
R1002020007_1002021007 1002020007 1002021007 2.500000e-02
L1002021007_1002022007 1002021007 1002022007 2.911707e-15

*4th-Plane-bottom-plate
*SM13
R1000000008_1000001008 1000000008 1000001008 2.500000e-02
L1000001008_1000002008 1000001008 1000002008 2.911707e-15
R1000002008_1000003008 1000002008 1000003008 2.500000e-02
L1000003008_1000004008 1000003008 1000004008 2.911707e-15

R1000000008_1001000008 1000000008 1001000008 2.500000e-02
L1001000008_1002000008 1001000008 1002000008 2.911707e-15
R1000002008_1001002008 1000002008 1001002008 2.500000e-02
L1001002008_1002002008 1001002008 1002002008 2.911707e-15
R1000004008_1001004008 1000004008 1001004008 2.500000e-02
L1001004008_1002004008 1001004008 1002004008 2.911707e-15

R1002000008_1002001008 1002000008 1002001008 2.500000e-02
L1002001008_1002002008 1002001008 1002002008 2.911707e-15
R1002002008_1002003008 1002002008 1002003008 2.500000e-02
L1002003008_1002004008 1002003008 1002004008 2.911707e-15

*Connection between SM9 and SM10
R1000004008_1000005008 1000004008 1000005008 2.500000e-02
L1000005008_1000006008 1000005008 1000006008 2.911707e-15
R1002004008_1002005008 1002004008 1002005008 2.500000e-02
L1002005008_1002006008 1002005008 1002006008 2.911707e-15

*SM14
R1000006008_1000007008 1000006008 1000007008 2.500000e-02
L1000007008_1000008008 1000007008 1000008008 2.911707e-15
R1000008008_1000009008 1000008008 1000009008 2.500000e-02
L1000009008_1000010008 1000009008 1000010008 2.911707e-15

R1000006008_1001006008 1000006008 1001006008 2.500000e-02
L1001006008_1002006008 1001006008 1002006008 2.911707e-15
R1000008008_1001008008 1000008008 1001008008 2.500000e-02
L1001008008_1002008008 1001008008 1002008008 2.911707e-15
R1000010008_1001010008 1000010008 1001010008 2.500000e-02
L1001010008_1002010008 1001010008 1002010008 2.911707e-15

R1002006008_1002007008 1002006008 1002007008 2.500000e-02
L1002007008_1002008008 1002007008 1002008008 2.911707e-15
R1002008008_1002009008 1002008008 1002009008 2.500000e-02
L1002009008_1002010008 1002009008 1002010008 2.911707e-15

*Connection between SM14 and SM15
R1000010008_1000011008 1000010008 1000011008 2.500000e-02
L1000011008_1000012008 1000011008 1000012008 2.911707e-15
R1002010008_1002011008 1002010008 1002011008 2.500000e-02
L1002011008_1002012008 1002011008 1002012008 2.911707e-15

*SM15
R1000012008_1000013008 1000012008 1000013008 2.500000e-02
L1000013008_1000014008 1000013008 1000014008 2.911707e-15
R1000014008_1000015008 1000014008 1000015008 2.500000e-02
L1000015008_1000016008 1000015008 1000016008 2.911707e-15

R1000012008_1001012008 1000012008 1001012008 2.500000e-02
L1001012008_1002012008 1001012008 1002012008 2.911707e-15
R1000014008_1001014008 1000014008 1001014008 2.500000e-02
L1001014008_1002014008 1001014008 1002014008 2.911707e-15
R1000016008_1001016008 1000016008 1001016008 2.500000e-02
L1001016008_1002016008 1001016008 1002016008 2.911707e-15

R1002012008_1002013008 1002012008 1002013008 2.500000e-02
L1002013008_1002014008 1002013008 1002014008 2.911707e-15
R1002014008_1002015008 1002014008 1002015008 2.500000e-02
L1002015008_1002016008 1002015008 1002016008 2.911707e-15

*Connection between SM15 and SM16
R1000016008_1000017008 1000016008 1000017008 2.500000e-02
L1000017008_1000018008 1000017008 1000018008 2.911707e-15
R1002016008_1002017008 1002016008 1002017008 2.500000e-02
L1002017008_1002018008 1002017008 1002018008 2.911707e-15

*SM16
R1000018008_1000019008 1000018008 1000019008 2.500000e-02
L1000019008_1000020008 1000019008 1000020008 2.911707e-15
R1000020008_1000021008 1000020008 1000021008 2.500000e-02
L1000021008_1000022008 1000021008 1000022008 2.911707e-15

R1000018008_1001018008 1000018008 1001018008 2.500000e-02
L1001018008_1002018008 1001018008 1002018008 2.911707e-15
R1000020008_1001020008 1000020008 1001020008 2.500000e-02
L1001020008_1002020008 1001020008 1002020008 2.911707e-15
R1000022008_1001022008 1000022008 1001022008 2.500000e-02
L1001022008_1002022008 1001022008 1002022008 2.911707e-15

R1002018008_1002019008 1002018008 1002019008 2.500000e-02
L1002019008_1002020008 1002019008 1002020008 2.911707e-15
R1002020008_1002021008 1002020008 1002021008 2.500000e-02
L1002021008_1002022008 1002021008 1002022008 2.911707e-15

*Power-Delivery-for-1st-plane
*SM1
R100_1000 100 1000 2.001600e-02
L1000_1000000001 1000 1000000001 0.3600000e-12
R100_1001 100 1001 2.001600e-02
L1001_1000002001 1001 1000002001 0.3600000e-12
R100_1002 100 1002 2.001600e-02
L1002_1000004001 1002 1000004001 0.3600000e-12
R100_1003 100 1003 2.001600e-02
L1003_1002000001 1003 1002000001 0.3600000e-12
R100_1004 100 1004 2.001600e-02
L1004_1002002001 1004 1002002001 0.3600000e-12
R100_1005 100 1005 2.001600e-02
L1005_1002004001 1005 1002004001 0.3600000e-12
*SM2
R100_1006 100 1006 2.001600e-02
L1006_1000006001 1006 1000006001 0.3600000e-12
R100_1007 100 1007 2.001600e-02
L1007_1000008001 1007 1000008001 0.3600000e-12
R100_1008 100 1008 2.001600e-02
L1008_1000010001 1008 1000010001 0.3600000e-12
R100_1009 100 1009 2.001600e-02
L1009_1002006001 1009 1002006001 0.3600000e-12
R100_1010 100 1010 2.001600e-02
L1010_1002008001 1010 1002008001 0.3600000e-12
R100_1011 100 1011 2.001600e-02
L1011_1002010001 1011 1002010001 0.3600000e-12
*SM3
R100_1012 100 1012 2.001600e-02
L1012_1000012001 1012 1000012001 0.3600000e-12
R100_1013 100 1013 2.001600e-02
L1013_1000014001 1013 1000014001 0.3600000e-12
R100_1014 100 1014 2.001600e-02
L1014_1000016001 1014 1000016001 0.3600000e-12
R100_1015 100 1015 2.001600e-02
L1015_1002012001 1015 1002012001 0.3600000e-12
R100_1016 100 1016 2.001600e-02
L1010_1002014001 1016 1002014001 0.3600000e-12
R100_1017 100 1017 2.001600e-02
L1017_1002016001 1017 1002016001 0.3600000e-12
*SM4
R100_1018 100 1018 2.001600e-02
L1018_1000018001 1018 1000018001 0.3600000e-12
R100_1019 100 1019 2.001600e-02
L1019_1000020001 1019 1000020001 0.3600000e-12
R100_1020 100 1020 2.001600e-02
L1020_1000022001 1020 1000022001 0.3600000e-12
R100_1021 100 1021 2.001600e-02
L1021_1002018001 1021 1002018001 0.3600000e-12
R100_1022 100 1022 2.001600e-02
L1022_1002020001 1022 1002020001 0.3600000e-12
R100_1023 100 1023 2.001600e-02
L1023_1002022001 1023 1002022001 0.3600000e-12

*Power-Delivery-for-4th-plane
*SM1
R0_2000 0 2000 2.001600e-02
L2000_1000000008 2000 1000000008 0.3600000e-12
R0_2001 0 2001 2.001600e-02
L2001_1000002008 2001 1000002008 0.3600000e-12
R0_2002 0 2002 2.001600e-02
L2002_1000004008 2002 1000004008 0.3600000e-12
R0_2003 0 2003 2.001600e-02
L2003_1002000008 2003 1002000008 0.3600000e-12
R0_2004 0 2004 2.001600e-02
L2004_1002002008 2004 1002002008 0.3600000e-12
R0_2005 0 2005 2.001600e-02
L2005_1002004008 2005 1002004008 0.3600000e-12

*SM2
R0_2006 0 2006 2.001600e-02
L2006_1000006008 2006 1000006008 0.3600000e-12
R0_2007 0 2007 2.001600e-02
L2007_1000008008 2007 1000008008 0.3600000e-12
R0_2008 0 2008 2.001600e-02
L2008_1000010008 2008 1000010008 0.3600000e-12
R0_2009 0 2009 2.001600e-02
L2009_1002006008 2009 1002006008 0.3600000e-12
R0_2010 0 2010 2.001600e-02
L2010_1002008008 2010 1002008008 0.3600000e-12
R0_2011 0 2011 2.001600e-02
L2011_1002010008 2011 1002010008 0.3600000e-12

*SM3
R0_2012 0 2012 2.001600e-02
L2012_1000012008 2012 1000012008 0.3600000e-12
R0_2013 0 2013 2.001600e-02
L2013_1000014008 2013 1000014008 0.3600000e-12
R0_2014 0 2014 2.001600e-02
L2014_1000016008 2014 1000016008 0.3600000e-12
R0_2015 0 2015 2.001600e-02
L2015_1002012008 2015 1002012008 0.3600000e-12
R0_2016 0 2016 2.001600e-02
L2010_1002014008 2016 1002014008 0.3600000e-12
R0_2017 0 2017 2.001600e-02
L2017_1002016008 2017 1002016008 0.3600000e-12

*SM4
R0_2018 0 2018 2.001600e-02
L2018_1000018008 2018 1000018008 0.3600000e-12
R0_2019 0 2019 2.001600e-02
L2019_1000020008 2019 1000020008 0.3600000e-12
R0_2020 0 2020 2.001600e-02
L2020_1000022008 2020 1000022008 0.3600000e-12
R0_2021 0 2021 2.001600e-02
L2021_1002018008 2021 1002018008 0.3600000e-12
R0_2022 0 2022 2.001600e-02
L2022_1002020008 2022 1002020008 0.3600000e-12
R0_2023 0 2023 2.001600e-02
L2023_1002022008 2023 1002022008 0.3600000e-12

*Load-Between-1st-2nd-plane
*SM1
C1000000001_1000000002 1000000001 1000000002 10.305556e-09
C1000002001_1000002002 1000002001 1000002002 10.305556e-09
C1000004001_1000004002 1000004001 1000004002 1210.305556e-09
C1002000001_1002000002 1002000001 1002000002 10.305556e-09
C1002002001_1002002002 1002002001 1002002002 10.305556e-09
C1002004001_1002004002 1002004001 1002004002 10.305556e-09
I1000000001_1000000002 1000000001 1000000002 DC 0.85
I1000002001_1000002002 1000002001 1000002002 DC 0.85
I1000004001_1000004002 1000004001 1000004002 DC 0.85
I1002000001_1002000002 1002000001 1002000002 DC 0.85
I1002002001_1002002002 1002002001 1002002002 DC 0.85
I1002004001_1002004002 1002004001 1002004002 DC 0.85
*SM2
C1000006001_1000006002 1000006001 1000006002 10.305556e-09
C1000008001_1000008002 1000008001 1000008002 10.305556e-09
C1000010001_1000010002 1000010001 1000010002 1210.305556e-09
C1002006001_1002006002 1002006001 1002006002 10.305556e-09
C1002008001_1002008002 1002008001 1002008002 10.305556e-09
C1002010001_1002010002 1002010001 1002010002 10.305556e-09
I1000006001_1000006002 1000006001 1000006002 DC 0.85
I1000008001_1000008002 1000008001 1000008002 DC 0.85
I1000010001_1000010002 1000010001 1000010002 DC 0.85
I1002006001_1002006002 1002006001 1002006002 DC 0.85
I1002008001_1002008002 1002008001 1002008002 DC 0.85
I1002010001_1002010002 1002010001 1002010002 DC 0.85
*SM3
C1000012001_1000012002 1000012001 1000012002 10.305556e-09
C1000014001_1000014002 1000014001 1000014002 10.305556e-09
C1000016001_1000016002 1000016001 1000016002 1210.305556e-09
C1002012001_1002012002 1002012001 1002012002 10.305556e-09
C1002014001_1002014002 1002014001 1002014002 10.305556e-09
C1002016001_1002016002 1002016001 1002016002 10.305556e-09
I1000012001_1000012002 1000012001 1000012002 DC 0.85
I1000014001_1000014002 1000014001 1000014002 DC 0.85
I1000016001_1000016002 1000016001 1000016002 DC 0.85
I1002012001_1002012002 1002012001 1002012002 DC 0.85
I1002014001_1002014002 1002014001 1002014002 DC 0.85
I1002016001_1002016002 1002016001 1002016002 DC 0.85
*SM4
C1000018001_1000018002 1000018001 1000018002 10.305556e-09
C1000020001_1000020002 1000020001 1000020002 10.305556e-09
C1000022001_1000022002 1000022001 1000022002 1210.305556e-09
C1002018001_1002018002 1002018001 1002018002 10.305556e-09
C1002020001_1002020002 1002020001 1002020002 10.305556e-09
C1002022001_1002022002 1002022001 1002022002 10.305556e-09
I1000018001_1000018002 1000018001 1000018002 DC 0.85
I1000020001_1000020002 1000020001 1000020002 DC 0.85
I1000022001_1000022002 1000022001 1000022002 DC 0.85
I1002018001_1002018002 1002018001 1002018002 DC 0.85
I1002020001_1002020002 1002020001 1002020002 DC 0.85
I1002022001_1002022002 1002022001 1002022002 DC 0.85

*Load-Between-3rd-4th-plane
*SM5
C1000000003_1000000004 1000000003 1000000004 10.305556e-09
C1000002003_1000002004 1000002003 1000002004 10.305556e-09
C1000004003_1000004004 1000004003 1000004004 1210.305556e-09
C1002000003_1002000004 1002000003 1002000004 10.305556e-09
C1002002003_1002002004 1002002003 1002002004 10.305556e-09
C1002004003_1002004004 1002004003 1002004004 10.305556e-09
I1000000003_1000000004 1000000003 1000000004 DC 0.85
I1000002003_1000002004 1000002003 1000002004 DC 0.85
I1000004003_1000004004 1000004003 1000004004 DC 0.85
I1002000003_1002000004 1002000003 1002000004 DC 0.85
I1002002003_1002002004 1002002003 1002002004 DC 0.85
I1002004003_1002004004 1002004003 1002004004 DC 0.85
*SM6
C1000006003_1000006004 1000006003 1000006004 10.305556e-09
C1000008003_1000008004 1000008003 1000008004 10.305556e-09
C1000010003_1000010004 1000010003 1000010004 1210.305556e-09
C1002006003_1002006004 1002006003 1002006004 10.305556e-09
C1002008003_1002008004 1002008003 1002008004 10.305556e-09
C1002010003_1002010004 1002010003 1002010004 10.305556e-09
I1000006003_1000006004 1000006003 1000006004 DC 0.85
I1000008003_1000008004 1000008003 1000008004 DC 0.85
I1000010003_1000010004 1000010003 1000010004 DC 0.85
I1002006003_1002006004 1002006003 1002006004 DC 0.85
I1002008003_1002008004 1002008003 1002008004 DC 0.85
I1002010003_1002010004 1002010003 1002010004 DC 0.85
*SM7
C1000012003_1000012004 1000012003 1000012004 10.305556e-09
C1000014003_1000014004 1000014003 1000014004 10.305556e-09
C1000016003_1000016004 1000016003 1000016004 1210.305556e-09
C1002012003_1002012004 1002012003 1002012004 10.305556e-09
C1002014003_1002014004 1002014003 1002014004 10.305556e-09
C1002016003_1002016004 1002016003 1002016004 10.305556e-09
I1000012003_1000012004 1000012003 1000012004 DC 0.85
I1000014003_1000014004 1000014003 1000014004 DC 0.85
I1000016003_1000016004 1000016003 1000016004 DC 0.85
I1002012003_1002012004 1002012003 1002012004 DC 0.85
I1002014003_1002014004 1002014003 1002014004 DC 0.85
I1002016003_1002016004 1002016003 1002016004 DC 0.85
*SM8
C1000018003_1000018004 1000018003 1000018004 10.305556e-09
C1000020003_1000020004 1000020003 1000020004 10.305556e-09
C1000022003_1000022004 1000022003 1000022004 1210.305556e-09
C1002018003_1002018004 1002018003 1002018004 10.305556e-09
C1002020003_1002020004 1002020003 1002020004 10.305556e-09
C1002022003_1002022004 1002022003 1002022004 10.305556e-09
I1000018003_1000018004 1000018003 1000018004 DC 0.85
I1000020003_1000020004 1000020003 1000020004 DC 0.85
I1000022003_1000022004 1000022003 1000022004 DC 0.85
I1002018003_1002018004 1002018003 1002018004 DC 0.85
I1002020003_1002020004 1002020003 1002020004 DC 0.85
I1002022003_1002022004 1002022003 1002022004 DC 0.85

*Load-Between-5th-6th-plane
*SM9
C1000000005_1000000006 1000000005 1000000006 10.305556e-09
C1000002005_1000002006 1000002005 1000002006 10.305556e-09
C1000004005_1000004006 1000004005 1000004006 1210.305556e-09
C1002000005_1002000006 1002000005 1002000006 10.305556e-09
C1002002005_1002002006 1002002005 1002002006 10.305556e-09
C1002004005_1002004006 1002004005 1002004006 10.305556e-09
I1000000005_1000000006 1000000005 1000000006 DC 0.85
I1000002005_1000002006 1000002005 1000002006 DC 0.85
I1000004005_1000004006 1000004005 1000004006 DC 0.85
I1002000005_1002000006 1002000005 1002000006 DC 0.85
I1002002005_1002002006 1002002005 1002002006 DC 0.85
I1002004005_1002004006 1002004005 1002004006 DC 0.85
*SM10
C1000006005_1000006006 1000006005 1000006006 10.305556e-09
C1000008005_1000008006 1000008005 1000008006 10.305556e-09
C1000010005_1000010006 1000010005 1000010006 1210.305556e-09
C1002006005_1002006006 1002006005 1002006006 10.305556e-09
C1002008005_1002008006 1002008005 1002008006 10.305556e-09
C1002010005_1002010006 1002010005 1002010006 10.305556e-09
I1000006005_1000006006 1000006005 1000006006 DC 0.85
I1000008005_1000008006 1000008005 1000008006 DC 0.85
I1000010005_1000010006 1000010005 1000010006 DC 0.85
I1002006005_1002006006 1002006005 1002006006 DC 0.85
I1002008005_1002008006 1002008005 1002008006 DC 0.85
I1002010005_1002010006 1002010005 1002010006 DC 0.85
*SM11
C1000012005_1000012006 1000012005 1000012006 10.305556e-09
C1000014005_1000014006 1000014005 1000014006 10.305556e-09
C1000016005_1000016006 1000016005 1000016006 1210.305556e-09
C1002012005_1002012006 1002012005 1002012006 10.305556e-09
C1002014005_1002014006 1002014005 1002014006 10.305556e-09
C1002016005_1002016006 1002016005 1002016006 10.305556e-09
I1000012005_1000012006 1000012005 1000012006 DC 0.85
I1000014005_1000014006 1000014005 1000014006 DC 0.85
I1000016005_1000016006 1000016005 1000016006 DC 0.85
I1002012005_1002012006 1002012005 1002012006 DC 0.85
I1002014005_1002014006 1002014005 1002014006 DC 0.85
I1002016005_1002016006 1002016005 1002016006 DC 0.85
*SM12
C1000018005_1000018006 1000018005 1000018006 10.305556e-09
C1000020005_1000020006 1000020005 1000020006 10.305556e-09
C1000022005_1000022006 1000022005 1000022006 1210.305556e-09
C1002018005_1002018006 1002018005 1002018006 10.305556e-09
C1002020005_1002020006 1002020005 1002020006 10.305556e-09
C1002022005_1002022006 1002022005 1002022006 10.305556e-09
I1000018005_1000018006 1000018005 1000018006 DC 0.85
I1000020005_1000020006 1000020005 1000020006 DC 0.85
I1000022005_1000022006 1000022005 1000022006 DC 0.85
I1002018005_1002018006 1002018005 1002018006 DC 0.85
I1002020005_1002020006 1002020005 1002020006 DC 0.85
I1002022005_1002022006 1002022005 1002022006 DC 0.85

*Load-Between-7th-8th-plane
*SM13
C1000000007_1000000008 1000000007 1000000008 10.305556e-09
C1000002007_1000002008 1000002007 1000002008 10.305556e-09
C1000004007_1000004008 1000004007 1000004008 1210.305556e-09
C1002000007_1002000008 1002000007 1002000008 10.305556e-09
C1002002007_1002002008 1002002007 1002002008 10.305556e-09
C1002004007_1002004008 1002004007 1002004008 10.305556e-09
I1000000007_1000000008 1000000007 1000000008 DC 0.85
I1000002007_1000002008 1000002007 1000002008 DC 0.85
I1000004007_1000004008 1000004007 1000004008 DC 0.85
I1002000007_1002000008 1002000007 1002000008 DC 0.85
I1002002007_1002002008 1002002007 1002002008 DC 0.85
I1002004007_1002004008 1002004007 1002004008 DC 0.85
*SM14
C1000006007_1000006008 1000006007 1000006008 10.305556e-09
C1000008007_1000008008 1000008007 1000008008 10.305556e-09
C1000010007_1000010008 1000010007 1000010008 1210.305556e-09
C1002006007_1002006008 1002006007 1002006008 10.305556e-09
C1002008007_1002008008 1002008007 1002008008 10.305556e-09
C1002010007_1002010008 1002010007 1002010008 10.305556e-09
I1000006007_1000006008 1000006007 1000006008 DC 0.85
I1000008007_1000008008 1000008007 1000008008 DC 0.85
I1000010007_1000010008 1000010007 1000010008 DC 0.85
I1002006007_1002006008 1002006007 1002006008 DC 0.85
I1002008007_1002008008 1002008007 1002008008 DC 0.85
I1002010007_1002010008 1002010007 1002010008 DC 0.85
*SM15
C1000012007_1000012008 1000012007 1000012008 10.305556e-09
C1000014007_1000014008 1000014007 1000014008 10.305556e-09
C1000016007_1000016008 1000016007 1000016008 1210.305556e-09
C1002012007_1002012008 1002012007 1002012008 10.305556e-09
C1002014007_1002014008 1002014007 1002014008 10.305556e-09
C1002016007_1002016008 1002016007 1002016008 10.305556e-09
I1000012007_1000012008 1000012007 1000012008 DC 0.85
I1000014007_1000014008 1000014007 1000014008 DC 0.85
I1000016007_1000016008 1000016007 1000016008 DC 0.85
I1002012007_1002012008 1002012007 1002012008 DC 0.85
I1002014007_1002014008 1002014007 1002014008 DC 0.85
I1002016007_1002016008 1002016007 1002016008 DC 0.85
*SM16
C1000018007_1000018008 1000018007 1000018008 10.305556e-09
C1000020007_1000020008 1000020007 1000020008 10.305556e-09
C1000022007_1000022008 1000022007 1000022008 1210.305556e-09
C1002018007_1002018008 1002018007 1002018008 10.305556e-09
C1002020007_1002020008 1002020007 1002020008 10.305556e-09
C1002022007_1002022008 1002022007 1002022008 10.305556e-09
I1000018007_1000018008 1000018007 1000018008 DC 0.85
I1000020007_1000020008 1000020007 1000020008 DC 0.85
I1000022007_1000022008 1000022007 1000022008 DC 0.85
I1002018007_1002018008 1002018007 1002018008 DC 0.85
I1002020007_1002020008 1002020007 1002020008 DC 0.85
I1002022007_1002022008 1002022007 1002022008 DC 0.85

*Connection between 2nd and 3rd plane
*SM1
r1000000002_1000000003 1000000002 1000000003 2.500000e-02
r1000002002_1000002003 1000002002 1000002003 2.500000e-02
r1000004002_1000004003 1000004002 1000004003 2.500000e-02
r1002000002_1002000003 1002000002 1002000003 2.500000e-02
r1002002002_1002002003 1002002002 1002002003 2.500000e-02
r1002004002_1002004003 1002004002 1002004003 2.500000e-02

*SM2
r1000006002_1000006003 1000006002 1000006003 2.500000e-02
r1000008002_1000008003 1000008002 1000008003 2.500000e-02
r1000010002_1000010003 1000010002 1000010003 2.500000e-02
r1002006002_1002006003 1002006002 1002006003 2.500000e-02
r1002008002_1002008003 1002008002 1002008003 2.500000e-02
r1002010002_1002010003 1002010002 1002010003 2.500000e-02

*SM3
r1000012002_1000012003 1000012002 1000012003 2.500000e-02
r1000014002_1000014003 1000014002 1000014003 2.500000e-02
r1000016002_1000016003 1000016002 1000016003 2.500000e-02
r1002012002_1002012003 1002012002 1002012003 2.500000e-02
r1002014002_1002014003 1002014002 1002014003 2.500000e-02
r1002016002_1002016003 1002016002 1002016003 2.500000e-02

*SM4
r1000018002_1000018003 1000018002 1000018003 2.500000e-02
r1000020002_1000020003 1000020002 1000020003 2.500000e-02
r1000022002_1000022003 1000022002 1000022003 2.500000e-02
r1002018002_1002018003 1002018002 1002018003 2.500000e-02
r1002020002_1002020003 1002020002 1002020003 2.500000e-02
r1002022002_1002022003 1002022002 1002022003 2.500000e-02

*Connection between 4th and 5th plane

r1000000004_1000000005 1000000004 1000000005 2.500000e-02
r1000002004_1000002005 1000002004 1000002005 2.500000e-02
r1000004004_1000004005 1000004004 1000004005 2.500000e-02
r1002000004_1002000005 1002000004 1002000005 2.500000e-02
r1002002004_1002002005 1002002004 1002002005 2.500000e-02
r1002004004_1002004005 1002004004 1002004005 2.500000e-02

r1000006004_1000006005 1000006004 1000006005 2.500000e-02
r1000008004_1000008005 1000008004 1000008005 2.500000e-02
r1000010004_1000010005 1000010004 1000010005 2.500000e-02
r1002006004_1002006005 1002006004 1002006005 2.500000e-02
r1002008004_1002008005 1002008004 1002008005 2.500000e-02
r1002010004_1002010005 1002010004 1002010005 2.500000e-02

r1000012004_1000012005 1000012004 1000012005 2.500000e-02
r1000014004_1000014005 1000014004 1000014005 2.500000e-02
r1000016004_1000016005 1000016004 1000016005 2.500000e-02
r1002012004_1002012005 1002012004 1002012005 2.500000e-02
r1002014004_1002014005 1002014004 1002014005 2.500000e-02
r1002016004_1002016005 1002016004 1002016005 2.500000e-02

r1000018004_1000018005 1000018004 1000018005 2.500000e-02
r1000020004_1000020005 1000020004 1000020005 2.500000e-02
r1000022004_1000022005 1000022004 1000022005 2.500000e-02
r1002018004_1002018005 1002018004 1002018005 2.500000e-02
r1002020004_1002020005 1002020004 1002020005 2.500000e-02
r1002022004_1002022005 1002022004 1002022005 2.500000e-02

*Connection between 6th and 7th plane

r1000000006_1000000007 1000000006 1000000007 2.500000e-02
r1000002006_1000002007 1000002006 1000002007 2.500000e-02
r1000004006_1000004007 1000004006 1000004007 2.500000e-02
r1002000006_1002000007 1002000006 1002000007 2.500000e-02
r1002002006_1002002007 1002002006 1002002007 2.500000e-02
r1002004006_1002004007 1002004006 1002004007 2.500000e-02

r1000006006_1000006007 1000006006 1000006007 2.500000e-02
r1000008006_1000008007 1000008006 1000008007 2.500000e-02
r1000010006_1000010007 1000010006 1000010007 2.500000e-02
r1002006006_1002006007 1002006006 1002006007 2.500000e-02
r1002008006_1002008007 1002008006 1002008007 2.500000e-02
r1002010006_1002010007 1002010006 1002010007 2.500000e-02

r1000012006_1000012007 1000012006 1000012007 2.500000e-02
r1000014006_1000014007 1000014006 1000014007 2.500000e-02
r1000016006_1000016007 1000016006 1000016007 2.500000e-02
r1002012006_1002012007 1002012006 1002012007 2.500000e-02
r1002014006_1002014007 1002014006 1002014007 2.500000e-02
r1002016006_1002016007 1002016006 1002016007 2.500000e-02

r1000018006_1000018007 1000018006 1000018007 2.500000e-02
r1000020006_1000020007 1000020006 1000020007 2.500000e-02
r1000022006_1000022007 1000022006 1000022007 2.500000e-02
r1002018006_1002018007 1002018006 1002018007 2.500000e-02
r1002020006_1002020007 1002020006 1002020007 2.500000e-02
r1002022006_1002022007 1002022006 1002022007 2.500000e-02

.MODEL switch1 SW (RON=0.005 ROFF=1e5 VT=0.99 VH=0)

*Stack1 VR
*Phase-1-Switches
switch1_1_1 1000002001 30000011 phase1 0 switch1 off
L1_1_1 30000011 3000001 0.36e-12
switch1_1_2 1000002003 30010011 phase1 0 switch1 off

r_on_power_1 30010011 300100111 0.0001

L1_1_2 300100111 3001001 0.36e-12
switch1_1_3 1000002005 30020011 phase1 0 switch1 off
L1_1_3 30020011 3002001 0.36e-12
switch1_1_4 1000002007 30030011 phase1 0 switch1 off
L1_1_4 30030011 3003001 0.36e-12
switch1_1_5 1000002002 40000011 phase1 0 switch1 off
L1_1_5 40000011 4000001 0.36e-12
switch1_1_6 1000002004 40010011 phase1 0 switch1 off
L1_1_6 40010011 4001001 0.36e-12
switch1_1_7 1000002006 40020011 phase1 0 switch1 off
L1_1_7 40020011 4002001 0.36e-12
switch1_1_8 1000002008 40030011 phase1 0 switch1 off
L1_1_8 40030011 4003001 0.36e-12

switch1_2_1 1000002002 30000011 phase2 0 switch1 off
L1_2_1 30000011 3000001 0.36e-12
switch1_2_2 1000002004 30010011 phase2 0 switch1 off
L1_2_2 30010011 3001001 0.36e-12
switch1_2_3 1000002006 30020011 phase2 0 switch1 off
L1_2_3 30020011 3002001 0.36e-12
switch1_2_4 1000002008 30030011 phase2 0 switch1 off
L1_2_4 30030011 3003001 0.36e-12
switch1_2_5 1000002001 40000011 phase2 0 switch1 off
L1_2_5 40000011 4000001 0.36e-12
switch1_2_6 1000002003 40010011 phase2 0 switch1 off
L1_2_6 40010011 4001001 0.36e-12
switch1_2_7 1000002005 40020011 phase2 0 switch1 off
L1_2_7 40020011 4002001 0.36e-12
switch1_2_8 1000002007 40030011 phase2 0 switch1 off
L1_2_8 40030011 4003001 0.36e-12

*Left-Capacitors
C3000001_3001001 3000001 3001001 0.253e-6
C3001001_3002001 3001001 3002001 0.253e-6
C3002001_3003001 3002001 3003001 0.253e-6
*Right-Capacitor
C4000001_4001001 4000001 4001001 0.253e-6
C4001001_4002001 4001001 4002001 0.253e-6
C4002001_4003001 4002001 4003001 0.253e-6

*Stack2 VR
*Phase-1-Switches
switch2_1_1 1000008001 30000021 phase1 0 switch1 off
L2_1_1 30000021 3000002 0.36e-12
switch2_1_2 1000008003 30010021 phase1 0 switch1 off

r_on_power_2 30010021 300100212 0.0001

L2_1_2 300100212 3001002 0.36e-12
switch2_1_3 1000008005 30020021 phase1 0 switch1 off
L2_1_3 30020021 3002002 0.36e-12
switch2_1_4 1000008007 30030021 phase1 0 switch1 off
L2_1_4 30030021 3003002 0.36e-12
switch2_1_5 1000008002 40000021 phase1 0 switch1 off
L2_1_5 40000021 4000002 0.36e-12
switch2_1_6 1000008004 40010021 phase1 0 switch1 off
L2_1_6 40010021 4001002 0.36e-12
switch2_1_7 1000008006 40020021 phase1 0 switch1 off
L2_1_7 40020021 4002002 0.36e-12
switch2_1_8 1000008008 40030021 phase1 0 switch1 off
L2_1_8 40030021 4003002 0.36e-12

switch2_2_1 1000008002 30000021 phase2 0 switch1 off
L2_2_1 30000021 3000002 0.36e-12
switch2_2_2 1000008004 30010021 phase2 0 switch1 off
L2_2_2 30010021 3001002 0.36e-12
switch2_2_3 1000008006 30020021 phase2 0 switch1 off
L2_2_3 30020021 3002002 0.36e-12
switch2_2_4 1000008008 30030021 phase2 0 switch1 off
L2_2_4 30030021 3003002 0.36e-12
switch2_2_5 1000008001 40000021 phase2 0 switch1 off
L2_2_5 40000021 4000002 0.36e-12
switch2_2_6 1000008003 40010021 phase2 0 switch1 off
L2_2_6 40010021 4001002 0.36e-12
switch2_2_7 1000008005 40020021 phase2 0 switch1 off
L2_2_7 40020021 4002002 0.36e-12
switch2_2_8 1000008007 40030021 phase2 0 switch1 off
L2_2_8 40030021 4003002 0.36e-12

*Left-Capacitors

C3000002_3001002 3000002 3001002 0.253e-6
C3001002_3002002 3001002 3002002 0.253e-6
C3002002_3003002 3002002 3003002 0.253e-6
*Right-Capacitor
C4000002_4001002 4000002 4001002 0.253e-6
C4001002_4002002 4001002 4002002 0.253e-6
C4002002_4003002 4002002 4003002 0.253e-6

*Stack3 VR
*Phase-1-Switches
switch3_1_1 1000014001 30000031 phase1 0 switch1 off
L3_1_1 30000031 3000003 0.36e-12
switch3_1_2 1000014003 30010031 phase1 0 switch1 off

r_on_power_3 30010031 300100313 0.0001

L3_1_2 300100313 3001003 0.36e-12
switch3_1_3 1000014005 30020031 phase1 0 switch1 off
L3_1_3 30020031 3002003 0.36e-12
switch3_1_4 1000014007 30030031 phase1 0 switch1 off
L3_1_4 30030031 3003003 0.36e-12
switch3_1_5 1000014002 40000031 phase1 0 switch1 off
L3_1_5 40000031 4000003 0.36e-12
switch3_1_6 1000014004 40010031 phase1 0 switch1 off
L3_1_6 40010031 4001003 0.36e-12
switch3_1_7 1000014006 40020031 phase1 0 switch1 off
L3_1_7 40020031 4002003 0.36e-12
switch3_1_8 1000014008 40030031 phase1 0 switch1 off
L3_1_8 40030031 4003003 0.36e-12

switch3_2_1 1000014002 30000031 phase2 0 switch1 off
L3_2_1 30000031 3000003 0.36e-12
switch3_2_2 1000014004 30010031 phase2 0 switch1 off
L3_2_2 30010031 3001003 0.36e-12
switch3_2_3 1000014006 30020031 phase2 0 switch1 off
L3_2_3 30020031 3002003 0.36e-12
switch3_2_4 1000014008 30030031 phase2 0 switch1 off
L3_2_4 30030031 3003003 0.36e-12
switch3_2_5 1000014001 40000031 phase2 0 switch1 off
L3_2_5 40000031 4000003 0.36e-12
switch3_2_6 1000014003 40010031 phase2 0 switch1 off
L3_2_6 40010031 4001003 0.36e-12
switch3_2_7 1000014005 40020031 phase2 0 switch1 off
L3_2_7 40020031 4002003 0.36e-12
switch3_2_8 1000014007 40030031 phase2 0 switch1 off
L3_2_8 40030031 4003003 0.36e-12

*Left-Capacitors
C3000003_3001003 3000003 3001003 0.253e-6
C3001003_3002003 3001003 3002003 0.253e-6
C3002003_3003003 3002003 3003003 0.253e-6
*Right-Capacitor
C4000003_4001003 4000003 4001003 0.253e-6
C4001003_4002003 4001003 4002003 0.253e-6
C4002003_4003003 4002003 4003003 0.253e-6

*Stack4 VR
*Phase-1-Switches
switch4_1_1 1000020001 30000041 phase1 0 switch1 off
L4_1_1 30000041 3000004 0.36e-12
switch4_1_2 1000020003 30010041 phase1 0 switch1 off

r_on_power_4 30010041 300100414 0.0001

L4_1_2 300100414 3001004 0.36e-12
switch4_1_3 1000020005 30020041 phase1 0 switch1 off
L4_1_3 30020041 3002004 0.36e-12
switch4_1_4 1000020007 30030041 phase1 0 switch1 off
L4_1_4 30030041 3003004 0.36e-12
switch4_1_5 1000020002 40000041 phase1 0 switch1 off
L4_1_5 40000041 4000004 0.36e-12
switch4_1_6 1000020004 40010041 phase1 0 switch1 off
L4_1_6 40010041 4001004 0.36e-12
switch4_1_7 1000020006 40020041 phase1 0 switch1 off
L4_1_7 40020041 4002004 0.36e-12
switch4_1_8 1000020008 40030041 phase1 0 switch1 off
L4_1_8 40030041 4003004 0.36e-12

switch4_2_1 1000020002 30000041 phase2 0 switch1 off
L4_2_1 30000041 3000004 0.36e-12
switch4_2_2 1000020004 30010041 phase2 0 switch1 off
L4_2_2 30010041 3001004 0.36e-12
switch4_2_3 1000020006 30020041 phase2 0 switch1 off
L4_2_3 30020041 3002004 0.36e-12
switch4_2_4 1000020008 30030041 phase2 0 switch1 off
L4_2_4 30030041 3003004 0.36e-12
switch4_2_5 1000020001 40000041 phase2 0 switch1 off
L4_2_5 40000041 4000004 0.36e-12
switch4_2_6 1000020003 40010041 phase2 0 switch1 off
L4_2_6 40010041 4001004 0.36e-12
switch4_2_7 1000020005 40020041 phase2 0 switch1 off
L4_2_7 40020041 4002004 0.36e-12
switch4_2_8 1000020007 40030041 phase2 0 switch1 off
L4_2_8 40030041 4003004 0.36e-12

*Left-Capacitors
C3000004_3001004 3000004 3001004 0.253e-6
C3001004_3002004 3001004 3002004 0.253e-6
C3002004_3003004 3002004 3003004 0.253e-6
*Right-Capacitor
C4000004_4001004 4000004 4001004 0.253e-6
C4001004_4002004 4001004 4002004 0.253e-6
C4002004_4003004 4002004 4003004 0.253e-6

V_phase1 phase1 0 pulse(0 1 0 1ps 1ps 10ns 20ns)
V_phase2 phase2 0 pulse(0 1 10ns 1ps 1ps 10ns 20ns)

*off-chip-voltage-regulator
*Off-chip VR

.MODEL switch2 SW (RON=0.1 ROFF=1e5 VT=0.99 VH=0)

*Stack2 VR
*Phase-1-Switches
switch2_1_10 1000010001 300000210 phase1_off 0 switch2 off
L2_1_10 300000210 30000020 10e-12
switch2_1_20 1000010003 300100210 phase1_off 0 switch2 off

r_off_power 300100210 300100211 0.0001

L2_1_20 300100211 30010020 10e-12
switch2_1_30 1000010005 300200210 phase1_off 0 switch2 off
L2_1_30 300200210 30020020 10e-12
switch2_1_40 1000010007 300300210 phase1_off 0 switch2 off
L2_1_40 300300210 30030020 10e-12
switch2_1_50 1000010002 400000210 phase1_off 0 switch2 off
L2_1_50 400000210 40000020 10e-12
switch2_1_60 1000010004 400100210 phase1_off 0 switch2 off
L2_1_60 400100210 40010020 10e-12
switch2_1_70 1000010006 400200210 phase1_off 0 switch2 off
L2_1_70 400200210 40020020 10e-12
switch2_1_80 1000010008 400300210 phase1_off 0 switch2 off
L2_1_80 400300210 40030020 10e-12

switch2_2_10 1000010002 300000210 phase2_off 0 switch2 off
L2_2_10 300000210 30000020 10e-12
switch2_2_20 1000010004 300100210 phase2_off 0 switch2 off
L2_2_20 300100210 30010020 10e-12
switch2_2_30 1000010006 300200210 phase2_off 0 switch2 off
L2_2_30 300200210 30020020 10e-12
switch2_2_40 1000010008 300300210 phase2_off 0 switch2 off
L2_2_40 300300210 30030020 10e-12
switch2_2_50 1000010001 400000210 phase2_off 0 switch2 off
L2_2_50 400000210 40000020 10e-12
switch2_2_60 1000010003 400100210 phase2_off 0 switch2 off
L2_2_60 400100210 40010020 10e-12
switch2_2_70 1000010005 400200210 phase2_off 0 switch2 off
L2_2_70 400200210 40020020 10e-12
switch2_2_80 1000010007 400300210 phase2_off 0 switch2 off
L2_2_80 400300210 40030020 10e-12

*Left-Capacitors
C30000020_30010020 30000020 30010020 67.1e-6
C30010020_30020020 30010020 30020020 67.1e-6
C30020020_30030020 30020020 30030020 67.1e-6
*Right-Capacitor
C40000020_40010020 40000020 40010020 67.1e-6
C40010020_40020020 40010020 40020020 67.1e-6
C40020020_40030020 40020020 40030020 67.1e-6

V_phase1_off phase1_off 0 pulse(0 1 0 2ps 2ps 500ns 1000ns)
V_phase2_off phase2_off 0 pulse(0 1 500ns 2ps 2ps 500ns 1000ns)

*Source
VDD 60 0 DC 4.1
*PCB and Package
R60_70 60 70 0.1e-3
L70_80 70 80 10.5e-12
R0_71 0 71 0.1e-3
L71_82 71 82 10.5e-12
R80_81 80 81 0.27e-3
C81_82 81 82 560e-6
R80_90 80 90 0.55e-3
L90_100 90 100 60e-12
R82_91 82 91 0.27e-3
L91_103 91 103 60e-12
R100_101 100 101 10e-3
L101_102 101 102 2.8e-12
C102_103 102 103 102e-6

.option trtol=1 sparse method=gear reltol=1m

.tran 97PS 10US uic

.END
